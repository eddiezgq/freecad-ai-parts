# Repository eddiezgq/freecad-ai-parts (continued)

## KiCad design factory/designs/ctrl-ls/kicad/ctrl-ls.kicad_pcb (continued)

Board: 4 copper layers, 250.0 x 150.0 mm, 258 parts (31 on the bottom side), 151 nets.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad

Their connections:
PE: H1.1; also elsewhere on the board

File factory/designs/ctrl-ls/order/bom_pcba.csv (part):

Comment,Designator,Footprint,LCSC Part #,贴装,型号,厂家,数量,物料编号
GBU1006,BR101,Diode_Bridge_GBU_D1.8mm,C5183365,插件,GBU1006,LGE,1,BRG-GBU1006
500MXH330MEFCSN30X50,C221 C222 C223,CP_Radial_D30.0mm_P10.00mm_SnapIn,C472902,插件,500MXH330MEFCSN30X50,Rubycon,3,CAP-BULK-330U-500V
1000u/10V,C307,CP_Radial_D8.0mm_P3.50mm,（通用件：按数值、封装配料）,插件,通用件 1000u/10V CP_Radial_D8.0mm_P3.50mm,,1,CAP-EL-1000U-10V
220u/25V,C306,CP_Radial_D8.0mm_P3.50mm,（通用件：按数值、封装配料）,插件,通用件 220u/25V CP_Radial_D8.0mm_P3.50mm,,1,CAP-EL-220U-25V
470u/35V,C304,CP_Radial_D10.0mm_P5.00mm,（通用件：按数值、封装配料）,插件,通用件 470u/35V CP_Radial_D10.0mm_P5.00mm,,1,CAP-EL-470U-35V
1u/450V,C104,C_Rect_L18.0mm_W8.0mm_P15.00mm_FKS3_FKP3,（通用件：按数值、封装配料）,插件,通用件 1u/450V C_Rect_L18.0mm_W8.0mm_P15.00mm_FKS3_FKP3,,1,CAP-FILM-1U-450V
BFC233920474,C101,C_Rect_L18.0mm_W11.0mm_P15.00mm_FKS3_FKP3,C511073,插件,BFC233920474,Vishay,1,CAP-X2-470N
DE1E3RA222MA4BP01F,C102 C103,C_Disc_D9.0mm_W5.0mm_P10.00mm,C907949,插件,DE1E3RA222MA4BP01F,Murata,2,CAP-Y-2N2
8118-RC,L101,L_CommonMode_Toroid_Vertical_L41.9mm_W20.3mm_Px15.24mm_Py22.86mm_Bourns_8100,（通用件：按数值、封装配料）,插件,8118-RC,Bourns,1,CMC-8118RC
AC IN L/N,J101,"TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizontal",（通用件：按数值、封装配料）,插件,"通用件 AC IN L/N TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizontal",,1,CONN-AC
MOTOR U/V/W,J401,"TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizontal",（通用件：按数值、封装配料）,插件,"通用件 MOTOR U/V/W TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizontal",,1,CONN-MOT
SOLENOIDS,J501,JST_VH_B8P-VH_1x08_P3.96mm_Vertical,（通用件：按数值、封装配料）,插件,通用件 SOLENOIDS JST_VH_B8P-VH_1x08_P3.96mm_Vertical,,1,CONN-VH8
PEDAL,J702,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,（通用件：按数值、封装配料）,插件,通用件 PEDAL JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,,1,CONN-XH3
STEPPER,J502,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,（通用件：按数值、封装配料）,插件,通用件 STEPPER JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,,1,CONN-XH4
PANEL,J601,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,（通用件：按数值、封装配料）,插件,通用件 PANEL JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,,1,CONN-XH4
ENCODER,J701,JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical,（通用件：按数值、封装配料）,插件,通用件 ENCODER JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical,,1,CONN-XH8
B0505S-1WR2,U602,Converter_SIP4_B0505S,C2992393,插件,B0505S-1WR2,YLPTEC,1,DCDC-B0505S
1N5408,D202,D_DO-201AD_P15.24mm_Horizontal,（通用件：按数值、封装配料）,插件,通用件 1N5408 D_DO-201AD_P15.24mm_Horizontal,,1,DIO-1N5408
C3D06060A,D201,TO-220-2_Vertical,C5693025,插件,C3D06060A,Wolfspeed (Cree),1,DIO-C3D06060A
0215010.MXP,F101,Fuseholder_Clip-5x20_XC-C3130_Pair,C142733,插件,0215010.MXP,Littelfuse,1,FUSE-T10A
TMC2226-SA,U501,HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.75x6.2mm_ThermalVias,C6718351,插件,TMC2226-SA,ADI / Trinamic,1,IC-TMC2226
STGIPS14K60T,U401,ST_SDIP-25L,C5268145,插件,STGIPS14K60T,STMicroelectronics,1,IPM-STGIPS14K60T
IPW60R060P7,Q201,TO-247-3_Vertical,C454258,插件,IPW60R060P7,Infineon,1,MOS-IPW60R060P7
B72214S0271K101,RV101,RV_Disc_D15.5mm_W5.0mm_P7.5mm_TDK_S14,C7502584,插件,B72214S0271K101,TDK,1,MOV-275
B57364S0259M000,TH101,NTC_Disc_D21.0mm_W7.0mm_P7.5mm_TDK_S364,C17362791,插件,B57364S0259M000,TDK,1,NTC-2R5
G5LE-1-E DC12,K101,Relay_SPDT_Omron-G5LE-1,C152711,插件,G5LE-1-E DC12,Omron,1,RLY-G5LE
100n,C40 C41 C42 C43 C46,C_0402_1005Metric,（通用件：按数值、封装配料）,贴片,通用件 100n C_0402_1005Metric,,5,CAP-0402
4.7u,C44,C_0402_1005Metric,（通用件：按数值、封装配料）,贴片,通用件 4.7u C_0402_1005Metric,,1,CAP-0402
1u,C45,C_0402_1005Metric,（通用件：按数值、封装配料）,贴片,通用件 1u C_0402_1005Metric,,1,CAP-0402
15p,C47 C48,C_0402_1005Metric,（通用件：按数值、封装配料）,贴片,通用件 15p C_0402_1005Metric,,2,CAP-0402
100n,C202 C207 C302 C308 C405 C506 C601 C602 C606 C701 C702,C_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 100n C_0603_1608Metric,,11,CAP-0603
1n,C205 C407 C409 C410 C411 C412 C413 C414 C415 C416 C417,C_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 1n C_0603_1608Metric,,11,CAP-0603
4.7n,C206,C_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 4.7n C_0603_1608Metric,,1,CAP-0603
10n,C408 C418,C_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 10n C_0603_1608Metric,,2,CAP-0603
22n/50V,C501,C_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 22n/50V C_0603_1608Metric,,1,CAP-0603
100n/50V,C502 C504,C_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 100n/50V C_0603_1608Metric,,2,CAP-0603
220p,C703 C704 C705 C706 C707 C708,C_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 220p C_0603_1608Metric,,6,CAP-0603
1u/25V,C201,C_0805_2012Metric,（通用件：按数值、封装配料）,贴片,通用件 1u/25V C_0805_2012Metric,,1,CAP-0805
3.3u/25V,C208,C_0805_2012Metric,（通用件：按数值、封装配料）,贴片,通用件 3.3u/25V C_0805_2012Metric,,1,CAP-0805
2.2u,C503,C_0805_2012Metric,（通用件：按数值、封装配料）,贴片,通用件 2.2u C_0805_2012Metric,,1,CAP-0805
1u/50V,C305,C_1206_3216Metric,（通用件：按数值、封装配料）,贴片,通用件 1u/50V C_1206_3216Metric,,1,CAP-1206
10u/25V,C309 C310 C404 C604 C605,C_1206_3216Metric,（通用件：按数值、封装配料）,贴片,通用件 10u/25V C_1206_3216Metric,,5,CAP-1206
4.7u/25V,C401 C402 C403 C603,C_1206_3216Metric,（通用件：按数值、封装配料）,贴片,通用件 4.7u/25V C_1206_3216Metric,,4,CAP-1206
10u/50V,C505,C_1210_3225Metric,（通用件：按数值、封装配料）,贴片,通用件 10u/50V C_1210_3225Metric,,1,CAP-1210
15n/1kV,C303,C_1812_4532Metric,（通用件：按数值、封装配料）,贴片,通用件 15n/1kV C_1812_4532Metric,,1,CAP-1812-1KV
100n/630V,C406,C_1812_4532Metric,（通用件：按数值、封装配料）,贴片,通用件 100n/630V C_1812_4532Metric,,1,CAP-1812-630V
47u/16V,C301,CP_Elec_6.3x5.4,（通用件：按数值、封装配料）,贴片,通用件 47u/16V CP_Elec_6.3x5.4,,1,CAP-EL-47U-16V
1N4007,D203 D204,D_SMA,（通用件：按数值、封装配料）,贴片,通用件 1N4007 D_SMA,,2,DIO-1N4007
1N4148W,D101,D_SOD-123,（通用件：按数值、封装配料）,贴片,通用件 1N4148W D_SOD-123,,1,DIO-1N4148W
ES3D,D302 D303 D304 D501 D502 D503 D504,D_SMC,C241735,贴片,ES3D,onsemi,7,DIO-ES3D
US1M,D301,D_SMA,（通用件：按数值、封装配料）,贴片,通用件 US1M D_SMA,,1,DIO-US1M
SN74LVC14APWR,U701,TSSOP-14_4.4x5mm_P0.65mm,C7663,贴片,SN74LVC14APWR,Texas Instruments,1,IC-74LVC14
ADUM1201ARZ-RL7,U601,SOIC-8_3.9x4.9mm_P1.27mm,C9669,贴片,ADUM1201ARZ-RL7,Analog Devices,1,IC-ADUM1201
AMS1117-3.3,U304 U603,SOT-223-3_TabPin2,（通用件：按数值、封装配料）,贴片,通用件 AMS1117-3.3 SOT-223-3_TabPin2,,2,IC-LDO-3V3
STM32G431CBT6,U10,LQFP-48_7x7mm_P0.5mm,C529355,贴片,STM32G431CBT6,STMicroelectronics,1,IC-MCU-MC
ICE3PCS01G,U201,SOIC-14_3.9x8.7mm_P1.27mm,C192050,贴片,ICE3PCS01G,Infineon,1,IC-PFC-ICE3PCS01G
MAX3485ESA+T,U604,SOIC-8_3.9x4.9mm_P1.27mm,C18148,贴片,MAX3485ESA+T,Analog Devices (Maxim),1,IC-RS485
TL431AIDBZR,U302,SOT-23,C23892,贴片,TL431AIDBZR,Texas Instruments,1,IC-TL431
TOP266KG,U301,PowerIntegrations_eSOP-12B,C568204,贴片,TOP266KG,Power Integrations,1,IC-TOP266KG
2N7002,Q101 Q202 Q505 Q506 Q507 Q508,SOT-23,（通用件：按数值、封装配料）,贴片,通用件 2N7002 SOT-23,,6,MOS-2N7002
BSC040N08NS5,Q501 Q502 Q503 Q504,TDSON-8-1,C534333,贴片,BSC040N08NS5,Infineon,4,MOS-80V
PC817X2NSZ9F,U303,SMDIP-4_W9.53mm,C390734,贴片,PC817X2NSZ9F,Sharp,1,OPTO-PC817
10k,R30,R_0402_1005Metric,（通用件：按数值、封装配料）,贴片,通用件 10k R_0402_1005Metric,,1,RES-0402
1k,R103 R308 R309 R402 R414 R415 R416 R709 R710 R711 R712 R713 R714,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 1k R_0603_1608Metric,,13,RES-0603
100k,R104 R210,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 100k R_0603_1608Metric,,2,RES-0603
3.3,R201,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 3.3 R_0603_1608Metric,,1,RES-0603
10k,R202 R306 R307 R401 R505 R506 R507 R508 R512 R513 R601 R701 R801,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 10k R_0603_1608Metric,,13,RES-0603
51,R204,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 51 R_0603_1608Metric,,1,RES-0603
66.5k,R205,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 66.5k R_0603_1608Metric,,1,RES-0603
200k,R206 R207 R209,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 200k R_0603_1608Metric,,3,RES-0603
330k,R208,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 330k R_0603_1608Metric,,1,RES-0603
130k,R213,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 130k R_0603_1608Metric,,1,RES-0603
20k,R217 R221 R702 R802,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 20k R_0603_1608Metric,,4,RES-0603
82k,R304,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 82k R_0603_1608Metric,,1,RES-0603
47k,R305,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 47k R_0603_1608Metric,,1,RES-0603
100,R403 R404 R405 R406 R407 R408,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 100 R_0603_1608Metric,,6,RES-0603
15k,R417 R418 R419,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 15k R_0603_1608Metric,,3,RES-0603
22k,R423 R511,R_0603_1608Metric,（通用件：按数值、封装配料）,贴片,通用件 22k R_0603_1608Metric,,2,RES-0603
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
## KiCad design factory/designs/drv-joint/kicad/drv-joint.kicad_pcb

Notes on the sheet:
关节伺服驱动板 DRV-JOINT：48 V、三相、相电流采样 + 编码器接口 + CAN。示例设计，未经硬件验证。

Parts:
C1: 470u/63V; CP_Elec_16x17.5
C2: 10n; C_0402_1005Metric
J1: 48V IN; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
NT10: NetTie; NetTie-2_SMD_Pad0.5mm
R1, R2: 51k; R_0402_1005Metric
R3: 6.8k; R_0402_1005Metric
TP14: EN12; TestPoint_Pad_D1.0mm
TP18: FB12; TestPoint_Pad_D1.0mm
TP50: SW12; TestPoint_Pad_D1.0mm
TP51: SW_CB; TestPoint_Pad_D1.0mm
TP53: VBUS_SNS; TestPoint_Pad_D1.0mm
TP57: VB_MID; TestPoint_Pad_D1.0mm

Connections:
EN12: TP14.1; also elsewhere on the board
FB12: TP18.1; also elsewhere on the board
GND: C1.2, C2.2, J1.2, R3.2; also elsewhere on the board
SW12: TP50.1; also elsewhere on the board
SW_CB: TP51.1; also elsewhere on the board
VBUS: C1.1, J1.1, NT10.1; also elsewhere on the board
VBUS_AUX: NT10.2, R1.1; also elsewhere on the board
VBUS_SNS: C2.1, R2.2, R3.1, TP53.1; also elsewhere on the board
VB_MID: R1.2, R2.1, TP57.1

Notes on the sheet:
48 V 从 J1 进；母线电容 C1 470 μF / 63 V（例题 3）；R1、R2、R3 分压给 MCU 测母线电压（48 V → 3.0 V）。示例设计，未经硬件验证。

Parts:
C3: 2.2u/100V; C_1206_3216Metric
C4: 100n; C_0402_1005Metric
C5: 22u/25V; C_1206_3216Metric
C6, C7: 10u/25V; C_1206_3216Metric
D1: 60V 1A; D_SMA
L1: 22u; L_Bourns_SRN6045TA
R4: 100k; R_0402_1005Metric
R5: 147k; R_0402_1005Metric
R6: 10k; R_0402_1005Metric
U1: LMR16006YQ; SOT-23-6
U2: AMS1117-5.0; SOT-223-3_TabPin2
U3: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C7.1, U3.2 (VO); also elsewhere on the board
+5V: C6.1, U2.2 (VO), U3.3 (VI); also elsewhere on the board
+12V: C5.1, L1.2, R5.1, U2.3 (VI); also elsewhere on the board
EN12: R4.2, U1.4 (~SHDN); also elsewhere on the board
FB12: R5.2, R6.1, U1.3 (FB); also elsewhere on the board
GND: C3.2, C5.2, C6.2, C7.2, D1.2 (A), R6.2, U1.2 (GND), U2.1 (GND), U3.1 (GND); also elsewhere on the board
SW12: C4.2, D1.1 (K), L1.1, U1.6 (SW); also elsewhere on the board
SW_CB: C4.1, U1.1 (CB); also elsewhere on the board
VBUS_AUX: C3.1, R4.1, U1.5 (VIN); also elsewhere on the board

Notes on the sheet:
U1 LMR16006Y 把 48 V 降到 12 V（栅极驱动用），U2、U3 线性稳压出 5 V（编码器、CAN）和 3.3 V（MCU、采样放大）。L1 22 μH、反馈 147 k / 10 k 的算法见设计说明。

Parts:
C11, C12, C13: 2.2u/100V; C_1206_3216Metric
Q1, Q2, Q3, Q4, Q5, Q6: BSC040N08NS5; TDSON-8-1

Connections:
GH_A: Q1.4 (G); also elsewhere on the board
GH_B: Q3.4 (G); also elsewhere on the board
GH_C: Q5.4 (G); also elsewhere on the board
GL_A: Q2.4 (G); also elsewhere on the board
GL_B: Q4.4 (G); also elsewhere on the board
GL_C: Q6.4 (G); also elsewhere on the board
GND: C11.2, C12.2, C13.2, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S); also elsewhere on the board
SW_A: Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D); also elsewhere on the board
SW_B: Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D); also elsewhere on the board
SW_C: Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.5 (D); also elsewhere on the board
VBUS: C11.1, C12.1, C13.1, Q1.5 (D), Q3.5 (D), Q5.5 (D); also elsewhere on the board

Notes on the sheet:
三个半桥，每相上下两个 MOSFET（示例选型 BSC040N08NS5，80 V）；C11–C13 每相就近吸收开关电流。

Parts:
C21, C22, C23, C24, C25, C26: 1u/25V; C_0402_1005Metric
D2, D3, D4: 100V 1A; D_SOD-123
NT7, NT8, NT9: NetTie; NetTie-2_SMD_Pad0.5mm
R10, R11, R12, R13, R14, R15: 10; R_0402_1005Metric
U4, U5, U6: IR2101S; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+12V: C24.1, C25.1, C26.1, D2.2 (A), D3.2 (A), D4.2 (A), U4.1 (VCC), U5.1 (VCC), U6.1 (VCC); also elsewhere on the board
GH_A: R10.2; also elsewhere on the board
GH_B: R12.2; also elsewhere on the board
GH_C: R14.2; also elsewhere on the board
GL_A: R11.2; also elsewhere on the board
GL_B: R13.2; also elsewhere on the board
GL_C: R15.2; also elsewhere on the board
GND: C24.2, C25.2, C26.2, U4.4 (COM), U5.4 (COM), U6.4 (COM); also elsewhere on the board
HO_A: R10.1, U4.7 (HO); also elsewhere on the board
HO_B: R12.1, U5.7 (HO); also elsewhere on the board
HO_C: R14.1, U6.7 (HO); also elsewhere on the board
LO_A: R11.1, U4.5 (LO); also elsewhere on the board
LO_B: R13.1, U5.5 (LO); also elsewhere on the board
LO_C: R15.1, U6.5 (LO); also elsewhere on the board
PWM_AH: U4.2 (HIN); also elsewhere on the board
PWM_AL: U4.3 (LIN); also elsewhere on the board
PWM_BH: U5.2 (HIN); also elsewhere on the board
PWM_BL: U5.3 (LIN); also elsewhere on the board
PWM_CH: U6.2 (HIN); also elsewhere on the board
PWM_CL: U6.3 (LIN); also elsewhere on the board
SW_A: NT7.1; also elsewhere on the board
SW_B: NT8.1; also elsewhere on the board
SW_C: NT9.1; also elsewhere on the board
VB_A: C21.1, D2.1 (K), U4.8 (VB); also elsewhere on the board
VB_B: C22.1, D3.1 (K), U5.8 (VB); also elsewhere on the board
VB_C: C23.1, D4.1 (K), U6.8 (VB); also elsewhere on the board
VS_A: C21.2, NT7.2, U4.6 (VS); also elsewhere on the board
VS_B: C22.2, NT8.2, U5.6 (VS); also elsewhere on the board
VS_C: C23.2, NT9.2, U6.6 (VS); also elsewhere on the board

Notes on the sheet:
每相一片半桥驱动 IR2101S：上管靠自举（D、C 1 μF）供电；栅极电阻 10 Ω（例题 2）；死区由 MCU 定时器给。

Parts:
C27, C28, C29: 100n; C_0402_1005Metric
C30, C31, C32: 1n; C_0402_1005Metric
J2: MOTOR UVW; TerminalBlock_Phoenix_MKDS-1,5-3_1x03_P5.00mm_Horizontal
NT1, NT2, NT3, NT4, NT5, NT6: NetTie; NetTie-2_SMD_Pad0.5mm
R21, R22, R23: 2m 1%; R_2512_6332Metric
U7, U8, U9: INA240A1D; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C27.1, C28.1, C29.1, U7.6 (V+), U7.7 (REF1), U8.6 (V+), U8.7 (REF1), U9.6 (V+), U9.7 (REF1); also elsewhere on the board
GND: C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, U7.2 (GND), U7.3 (REF2), U7.4 (GND), U8.2 (GND), U8.3 (REF2), U8.4 (GND), U9.2 (GND), U9.3 (REF2), U9.4 (GND); also elsewhere on the board
ISNS_A: C30.1, U7.5; also elsewhere on the board
ISNS_B: C31.1, U8.5; also elsewhere on the board
ISNS_C: C32.1, U9.5; also elsewhere on the board
MOT_A: J2.1, NT2.1, R21.2
MOT_B: J2.2, NT4.1, R22.2
MOT_C: J2.3, NT6.1, R23.2
SNSN_A: NT2.2, U7.1 (-); also elsewhere on the board
SNSN_B: NT4.2, U8.1 (-); also elsewhere on the board
SNSN_C: NT6.2, U9.1 (-); also elsewhere on the board
SNSP_A: NT1.2, U7.8 (+); also elsewhere on the board
SNSP_B: NT3.2, U8.8 (+); also elsewhere on the board
SNSP_C: NT5.2, U9.8 (+); also elsewhere on the board
SW_A: NT1.1, R21.1; also elsewhere on the board
SW_B: NT3.1, R22.1; also elsewhere on the board
SW_C: NT5.1, R23.1; also elsewhere on the board

Notes on the sheet:
相线上串 2 mΩ 采样电阻（R21–R23），INA240A1 放大 20 倍：40 mV/A，零点 1.65 V，量程 ±41 A（例题 1）。J2 接电机三相。
