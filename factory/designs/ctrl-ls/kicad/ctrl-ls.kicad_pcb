# Repository eddiezgq/freecad-ai-parts (continued)

## KiCad design factory/designs/drv-joint/kicad/drv-joint.kicad_pcb (continued)

Parts:
C40, C41, C42, C43, C46: 100n; C_0402_1005Metric
C44: 4.7u; C_0402_1005Metric
C45: 1u; C_0402_1005Metric
C47, C48: 10p; C_0402_1005Metric
R30: 10k; R_0402_1005Metric
TP1: SWDIO; TestPoint_Pad_D1.0mm
TP2: SWCLK; TestPoint_Pad_D1.0mm
TP3: NRST; TestPoint_Pad_D1.0mm
TP4: +3V3; TestPoint_Pad_D1.0mm
TP5: GND; TestPoint_Pad_D1.0mm
TP10: +12V; TestPoint_Pad_D1.0mm
TP11: BOOT0; TestPoint_Pad_D1.0mm
TP12: CAN_RXD; TestPoint_Pad_D1.0mm
TP13: CAN_TXD; TestPoint_Pad_D1.0mm
TP15: ENC_A_F; TestPoint_Pad_D1.0mm
TP16: ENC_B_F; TestPoint_Pad_D1.0mm
TP17: ENC_Z_F; TestPoint_Pad_D1.0mm
TP19: GH_A; TestPoint_Pad_D1.0mm
TP20: GH_B; TestPoint_Pad_D1.0mm
TP21: GH_C; TestPoint_Pad_D1.0mm
TP22: GL_A; TestPoint_Pad_D1.0mm
TP23: GL_B; TestPoint_Pad_D1.0mm
TP24: GL_C; TestPoint_Pad_D1.0mm
TP25: HO_A; TestPoint_Pad_D1.0mm
TP26: HO_B; TestPoint_Pad_D1.0mm
TP27: HO_C; TestPoint_Pad_D1.0mm
TP28: ISNS_A; TestPoint_Pad_D1.0mm
TP29: ISNS_B; TestPoint_Pad_D1.0mm
TP30: ISNS_C; TestPoint_Pad_D1.0mm
TP31: LO_A; TestPoint_Pad_D1.0mm
TP32: LO_B; TestPoint_Pad_D1.0mm
TP33: LO_C; TestPoint_Pad_D1.0mm
TP34: OSC_IN; TestPoint_Pad_D1.0mm
TP35: OSC_OUT; TestPoint_Pad_D1.0mm
TP36: PWM_AH; TestPoint_Pad_D1.0mm
TP37: PWM_AL; TestPoint_Pad_D1.0mm
TP38: PWM_BH; TestPoint_Pad_D1.0mm
TP39: PWM_BL; TestPoint_Pad_D1.0mm
TP40: PWM_CH; TestPoint_Pad_D1.0mm
TP41: PWM_CL; TestPoint_Pad_D1.0mm
TP42: SNSN_A; TestPoint_Pad_D1.0mm
TP43: SNSN_B; TestPoint_Pad_D1.0mm
TP44: SNSN_C; TestPoint_Pad_D1.0mm
TP45: SNSP_A; TestPoint_Pad_D1.0mm
TP46: SNSP_B; TestPoint_Pad_D1.0mm
TP47: SNSP_C; TestPoint_Pad_D1.0mm
TP48: SSI_CLK; TestPoint_Pad_D1.0mm
TP49: SSI_DATA; TestPoint_Pad_D1.0mm
TP52: VBUS_AUX; TestPoint_Pad_D1.0mm
TP54: VB_A; TestPoint_Pad_D1.0mm
TP55: VB_B; TestPoint_Pad_D1.0mm
TP56: VB_C; TestPoint_Pad_D1.0mm
TP58: VS_A; TestPoint_Pad_D1.0mm
TP59: VS_B; TestPoint_Pad_D1.0mm
TP60: VS_C; TestPoint_Pad_D1.0mm
U10: STM32G431CBT6; LQFP-48_7x7mm_P0.5mm
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, TP4.1, U10.1 (VBAT), U10.20 (VREF+), U10.21 (VDDA), U10.24 (VDD), U10.36 (VDD), U10.48 (VDD); also elsewhere on the board
+12V: TP10.1; also elsewhere on the board
BOOT0: R30.1, TP11.1, U10.45 (PB8)
CAN_RXD: TP12.1, U10.33 (PA11); also elsewhere on the board
CAN_TXD: TP13.1, U10.34 (PA12); also elsewhere on the board
ENC_A_F: TP15.1, U10.14 (PA6); also elsewhere on the board
ENC_B_F: TP16.1, U10.15 (PA7); also elsewhere on the board
ENC_Z_F: TP17.1, U10.16 (PB0); also elsewhere on the board
GH_A: TP19.1; also elsewhere on the board
GH_B: TP20.1; also elsewhere on the board
GH_C: TP21.1; also elsewhere on the board
GL_A: TP22.1; also elsewhere on the board
GL_B: TP23.1; also elsewhere on the board
GL_C: TP24.1; also elsewhere on the board
GND: C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, R30.2, TP5.1, U10.19 (VSSA), U10.23 (VSS), U10.35 (VSS), U10.47 (VSS), Y1.2, Y1.4; also elsewhere on the board
HO_A: TP25.1; also elsewhere on the board
HO_B: TP26.1; also elsewhere on the board
HO_C: TP27.1; also elsewhere on the board
ISNS_A: TP28.1, U10.8 (PA0); also elsewhere on the board
ISNS_B: TP29.1, U10.9 (PA1); also elsewhere on the board
ISNS_C: TP30.1, U10.10 (PA2); also elsewhere on the board
LO_A: TP31.1; also elsewhere on the board
LO_B: TP32.1; also elsewhere on the board
LO_C: TP33.1; also elsewhere on the board
NRST: C46.1, TP3.1, U10.7 (PG10)
OSC_IN: C47.1, TP34.1, U10.5 (PF0), Y1.1
OSC_OUT: C48.1, TP35.1, U10.6 (PF1), Y1.3
PWM_AH: TP36.1, U10.30 (PA8); also elsewhere on the board
PWM_AL: TP37.1, U10.27 (PB13); also elsewhere on the board
PWM_BH: TP38.1, U10.31 (PA9); also elsewhere on the board
PWM_BL: TP39.1, U10.28 (PB14); also elsewhere on the board
PWM_CH: TP40.1, U10.32 (PA10); also elsewhere on the board
PWM_CL: TP41.1, U10.29 (PB15); also elsewhere on the board
SNSN_A: TP42.1; also elsewhere on the board
SNSN_B: TP43.1; also elsewhere on the board
SNSN_C: TP44.1; also elsewhere on the board
SNSP_A: TP45.1; also elsewhere on the board
SNSP_B: TP46.1; also elsewhere on the board
SNSP_C: TP47.1; also elsewhere on the board
SSI_CLK: TP48.1, U10.40 (PB3); also elsewhere on the board
SSI_DATA: TP49.1, U10.41 (PB4); also elsewhere on the board
SWCLK: TP2.1, U10.38 (PA14)
SWDIO: TP1.1, U10.37 (PA13)
VBUS_AUX: TP52.1; also elsewhere on the board
VBUS_SNS: U10.11 (PA3); also elsewhere on the board
VB_A: TP54.1; also elsewhere on the board
VB_B: TP55.1; also elsewhere on the board
VB_C: TP56.1; also elsewhere on the board
VS_A: TP58.1; also elsewhere on the board
VS_B: TP59.1; also elsewhere on the board
VS_C: TP60.1; also elsewhere on the board

Notes on the sheet:
STM32G431（示例选型）：TIM1 三相互补 PWM、ADC 采三相电流与母线电压、TIM3 编码器、SPI1 读 SSI、FDCAN1；8 MHz 晶振；TP1–TP5 是烧录口和电源测试点。

Parts:
C50, C51, C52: 220p; C_0402_1005Metric
C53, C54, C55, C56: 100n; C_0402_1005Metric
J3: ENC ABZ; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J4: ENC SSI; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J5: CAN; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R31, R32, R33: 1k; R_0402_1005Metric
R34, R35: 120; R_0402_1005Metric
U11, U12: MAX3485; SOIC-8_3.9x4.9mm_P1.27mm
U13: MCP2562-E/SN; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C53.1, C54.1, C56.1, U11.2 (~RE), U11.3 (DE), U11.8 (VCC), U12.8 (VCC), U13.5 (Vio); also elsewhere on the board
+5V: C55.1, J3.1, J4.1, J5.4, U13.3 (VDD); also elsewhere on the board
CANH: J5.1, R35.1, U13.7 (CANH)
CANL: J5.2, R35.2, U13.6 (CANL)
CAN_RXD: U13.4 (RXD); also elsewhere on the board
CAN_TXD: U13.1 (TXD); also elsewhere on the board
ENC_A: J3.3, R31.1
ENC_A_F: C50.1, R31.2; also elsewhere on the board
ENC_B: J3.4, R32.1
ENC_B_F: C51.1, R32.2; also elsewhere on the board
ENC_Z: J3.5, R33.1
ENC_Z_F: C52.1, R33.2; also elsewhere on the board
GND: C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, J3.2, J4.2, J5.3, U11.5 (GND), U12.2 (~RE), U12.3 (DE), U12.4 (DI), U12.5 (GND), U13.2 (VSS), U13.8 (STBY); also elsewhere on the board
SSIC_N: J4.4, U11.7 (B)
SSIC_P: J4.3, U11.6 (A)
SSID_N: J4.6, R34.2, U12.7 (B)
SSID_P: J4.5, R34.1, U12.6 (A)
SSI_CLK: U11.4 (DI); also elsewhere on the board
SSI_DATA: U12.1 (RO); also elsewhere on the board

Notes on the sheet:
J3 增量编码器 A/B/Z 经 1 kΩ / 220 pF 滤波（例题 4）进 MCU；J4 输出端绝对值编码器 SSI（两片 RS-485 收发）；J5 CAN（MCP2562，120 Ω 终端）。

Board: 4 copper layers, 100.0 x 70.0 mm, 159 parts (56 on the bottom side), 73 nets.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad

Their connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

File factory/designs/drv-joint/out/bom.csv:

物料编号,数值,封装,数量,位号,说明
CAP-0402,100n,C_0402_1005Metric,13,C4 C27 C28 C29 C40 C41 C42 C43 C46 C53 C54 C55 C56,自举电容
CAP-0402,10n,C_0402_1005Metric,1,C2,
CAP-0402,10p,C_0402_1005Metric,2,C47 C48,
CAP-0402,1n,C_0402_1005Metric,3,C30 C31 C32,ADC 抗混叠
CAP-0402,1u,C_0402_1005Metric,1,C45,VDDA
CAP-0402,1u/25V,C_0402_1005Metric,6,C21 C22 C23 C24 C25 C26,自举电容
CAP-0402,220p,C_0402_1005Metric,3,C50 C51 C52,
CAP-0402,4.7u,C_0402_1005Metric,1,C44,
CAP-1206,10u/25V,C_1206_3216Metric,2,C6 C7,
CAP-1206,2.2u/100V,C_1206_3216Metric,4,C3 C11 C12 C13,
CAP-1206,22u/25V,C_1206_3216Metric,1,C5,
CAP-BULK,470u/63V,CP_Elec_16x17.5,1,C1,母线电容（例题 3）
CONN-PWR,48V IN,"TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal",1,J1,
CONN-PWR,MOTOR UVW,"TerminalBlock_Phoenix_MKDS-1,5-3_1x03_P5.00mm_Horizontal",1,J2,
CONN-SIG,CAN,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,J5,
CONN-SIG,ENC ABZ,JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical,1,J3,A/B/Z（2500 线，示例）
CONN-SIG,ENC SSI,JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical,1,J4,输出端绝对值编码器
DIO-SMD,100V 1A,D_SOD-123,3,D2 D3 D4,自举二极管
DIO-SMD,60V 1A,D_SMA,1,D1,续流二极管
IC-AMP,INA240A1D,SOIC-8_3.9x4.9mm_P1.27mm,3,U7 U8 U9,A 相电流采样放大 20 倍（示例选型）
IC-BUCK,LMR16006YQ,SOT-23-6,1,U1,48 V → 12 V 降压（示例选型）
IC-CAN,MCP2562-E/SN,SOIC-8_3.9x4.9mm_P1.27mm,1,U13,CAN 收发（示例选型）
IC-GDRV,IR2101S,SOIC-8_3.9x4.9mm_P1.27mm,3,U4 U5 U6,A 相半桥驱动（示例选型）
IC-LDO,AMS1117-3.3,SOT-223-3_TabPin2,1,U3,
IC-LDO,AMS1117-5.0,SOT-223-3_TabPin2,1,U2,
IC-MCU-MC,STM32G431CBT6,LQFP-48_7x7mm_P0.5mm,1,U10,电机控制 MCU（示例选型）：TIM1 三相互补 PWM、ADC 采三相电流与母线、TIM3 编码器、SPI1 读 SSI、FDCAN1
IC-RS485,MAX3485,SOIC-8_3.9x4.9mm_P1.27mm,2,U11 U12,SSI 时钟发送（示例选型）
IND-PWR,22u,L_Bourns_SRN6045TA,1,L1,
MOS-80V,BSC040N08NS5,TDSON-8-1,6,Q1 Q2 Q3 Q4 Q5 Q6,A 相上管（示例选型）
RES-0402,10,R_0402_1005Metric,6,R10 R11 R12 R13 R14 R15,栅极电阻（例题 2）
RES-0402,100k,R_0402_1005Metric,1,R4,使能上拉
RES-0402,10k,R_0402_1005Metric,2,R6 R30,反馈下电阻
RES-0402,120,R_0402_1005Metric,2,R34 R35,终端电阻
RES-0402,147k,R_0402_1005Metric,1,R5,反馈上电阻
RES-0402,1k,R_0402_1005Metric,3,R31 R32 R33,编码器滤波（例题 4）
RES-0402,51k,R_0402_1005Metric,2,R1 R2,母线电压分压
RES-0402,6.8k,R_0402_1005Metric,1,R3,
RES-SHUNT,2m 1%,R_2512_6332Metric,3,R21 R22 R23,A 相采样电阻（例题 1），两端开尔文引线到 INA240
XTAL,8MHz,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,Y1,

## KiCad design factory/designs/drv-joint-b/kicad/drv-joint-b.kicad_pcb

Notes on the sheet:
关节伺服驱动板 DRV-JOINT：48 V、三相、相电流采样 + 编码器接口 + CAN。示例设计，未经硬件验证。

Parts:
C1: 470u/63V; CP_Elec_16x17.5
C2: 10n; C_0402_1005Metric
C62, C63: 1u; C_0402_1005Metric
D5: 100V 1A; D_SMA
J1: 48V IN; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
J6: BRAKE; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
NT10: NetTie; NetTie-2_SMD_Pad0.5mm
Q7: BSC040N08NS5; TDSON-8-1
R1, R2: 51k; R_0402_1005Metric
R3: 6.8k; R_0402_1005Metric
R36: 10; R_0402_1005Metric
R37: 10k; R_0402_1005Metric
R38: 100k; R_0402_1005Metric
R39: 0.5; R_0805_2012Metric
R40: 1k; R_0402_1005Metric
TP20: EN12; TestPoint_Pad_D1.0mm
TP30: FB12; TestPoint_Pad_D1.0mm
TP62: SW12; TestPoint_Pad_D1.0mm
TP63: SW_CB; TestPoint_Pad_D1.0mm
TP65: VBUS_SNS; TestPoint_Pad_D1.0mm
TP69: VB_MID; TestPoint_Pad_D1.0mm
U16: UCC27511ADBV; SOT-23-6

Connections:
+12V: C62.1, U16.1 (V_{DD}); also elsewhere on the board
BRK_G: Q7.4 (G), R36.2, R37.1; also elsewhere on the board
BRK_GD: R36.1, U16.2 (OUTH), U16.3 (OUTL); also elsewhere on the board
BRK_ISEN: C63.1, R40.2; also elsewhere on the board
BRK_N: D5.2 (A), J6.2, Q7.5 (D)
BRK_PWM: R38.1, U16.6 (IN+); also elsewhere on the board
BRK_S: Q7.1 (S), Q7.2 (S), Q7.3 (S), R39.1, R40.1; also elsewhere on the board
EN12: TP20.1; also elsewhere on the board
FB12: TP30.1; also elsewhere on the board
GND: C1.2, C2.2, C62.2, C63.2, J1.2, R3.2, R37.2, R38.2, R39.2, U16.4 (GND), U16.5 (IN-); also elsewhere on the board
SW12: TP62.1; also elsewhere on the board
SW_CB: TP63.1; also elsewhere on the board
VBUS: C1.1, D5.1 (K), J1.1, J6.1, NT10.1; also elsewhere on the board
VBUS_AUX: NT10.2, R1.1; also elsewhere on the board
VBUS_SNS: C2.1, R2.2, R3.1, TP65.1; also elsewhere on the board
VB_MID: R1.2, R2.1, TP69.1

Notes on the sheet:
48 V 从 J1 进；C1 母线电容；R1–R3 分压测母线电压。B 版加抱闸（第 110 轮）：J6 接抱闸线圈，U16 + Q7 从母线 PWM 供电，D5 续流，R38 下拉（MCU 没输出就抱住）；R39 采样线圈电流经 R40、C63 滤波进 PB0（第 114 轮）。示例设计，未经硬件验证。

Parts:
C3: 2.2u/100V; C_1206_3216Metric
C4: 100n; C_0402_1005Metric
C5: 22u/25V; C_1206_3216Metric
C6, C7: 10u/25V; C_1206_3216Metric
D1: 60V 1A; D_SMA
L1: 22u; L_Bourns_SRN6045TA
R4: 100k; R_0402_1005Metric
R5: 147k; R_0402_1005Metric
R6: 10k; R_0402_1005Metric
U1: LMR16006YQ; SOT-23-6
U2: AMS1117-5.0; SOT-223-3_TabPin2
U3: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C7.1, U3.2 (VO); also elsewhere on the board
+5V: C6.1, U2.2 (VO), U3.3 (VI); also elsewhere on the board
+12V: C5.1, L1.2, R5.1, U2.3 (VI); also elsewhere on the board
EN12: R4.2, U1.4 (~SHDN); also elsewhere on the board
FB12: R5.2, R6.1, U1.3 (FB); also elsewhere on the board
GND: C3.2, C5.2, C6.2, C7.2, D1.2 (A), R6.2, U1.2 (GND), U2.1 (GND), U3.1 (GND); also elsewhere on the board
SW12: C4.2, D1.1 (K), L1.1, U1.6 (SW); also elsewhere on the board
SW_CB: C4.1, U1.1 (CB); also elsewhere on the board
VBUS_AUX: C3.1, R4.1, U1.5 (VIN); also elsewhere on the board

Notes on the sheet:
U1 LMR16006Y 把 48 V 降到 12 V（栅极驱动用），U2、U3 线性稳压出 5 V（编码器、CAN）和 3.3 V（MCU、采样放大）。L1 22 μH、反馈 147 k / 10 k 的算法见设计说明。
