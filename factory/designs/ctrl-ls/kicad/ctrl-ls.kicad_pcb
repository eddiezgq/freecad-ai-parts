# Repository eddiezgq/freecad-ai-parts (continued)

## KiCad design factory/designs/drv-joint-b/kicad/drv-joint-b.kicad_pcb (continued)

Parts:
C11, C12, C13: 2.2u/100V; C_1206_3216Metric
Q1, Q2, Q3, Q4, Q5, Q6: BSC040N08NS5; TDSON-8-1

Connections:
GH_A: Q1.4 (G); also elsewhere on the board
GH_B: Q3.4 (G); also elsewhere on the board
GH_C: Q5.4 (G); also elsewhere on the board
GL_A: Q2.4 (G); also elsewhere on the board
GL_B: Q4.4 (G); also elsewhere on the board
GL_C: Q6.4 (G); also elsewhere on the board
GND: C11.2, C12.2, C13.2, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S); also elsewhere on the board
SW_A: Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D); also elsewhere on the board
SW_B: Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D); also elsewhere on the board
SW_C: Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.5 (D); also elsewhere on the board
VBUS: C11.1, C12.1, C13.1, Q1.5 (D), Q3.5 (D), Q5.5 (D); also elsewhere on the board

Notes on the sheet:
三个半桥，每相上下两个 MOSFET（示例选型 BSC040N08NS5，80 V）；C11–C13 每相就近吸收开关电流。

Parts:
C21, C22, C23, C24, C25, C26: 1u/25V; C_0402_1005Metric
D2, D3, D4: 100V 1A; D_SOD-123
NT7, NT8, NT9: NetTie; NetTie-2_SMD_Pad0.5mm
R10, R11, R12, R13, R14, R15: 10; R_0402_1005Metric
U4, U5, U6: IR2101S; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+12V: C24.1, C25.1, C26.1, D2.2 (A), D3.2 (A), D4.2 (A), U4.1 (VCC), U5.1 (VCC), U6.1 (VCC); also elsewhere on the board
GH_A: R10.2; also elsewhere on the board
GH_B: R12.2; also elsewhere on the board
GH_C: R14.2; also elsewhere on the board
GL_A: R11.2; also elsewhere on the board
GL_B: R13.2; also elsewhere on the board
GL_C: R15.2; also elsewhere on the board
GND: C24.2, C25.2, C26.2, U4.4 (COM), U5.4 (COM), U6.4 (COM); also elsewhere on the board
HO_A: R10.1, U4.7 (HO); also elsewhere on the board
HO_B: R12.1, U5.7 (HO); also elsewhere on the board
HO_C: R14.1, U6.7 (HO); also elsewhere on the board
LO_A: R11.1, U4.5 (LO); also elsewhere on the board
LO_B: R13.1, U5.5 (LO); also elsewhere on the board
LO_C: R15.1, U6.5 (LO); also elsewhere on the board
PWM_AH: U4.2 (HIN); also elsewhere on the board
PWM_AL: U4.3 (LIN); also elsewhere on the board
PWM_BH: U5.2 (HIN); also elsewhere on the board
PWM_BL: U5.3 (LIN); also elsewhere on the board
PWM_CH: U6.2 (HIN); also elsewhere on the board
PWM_CL: U6.3 (LIN); also elsewhere on the board
SW_A: NT7.1; also elsewhere on the board
SW_B: NT8.1; also elsewhere on the board
SW_C: NT9.1; also elsewhere on the board
VB_A: C21.1, D2.1 (K), U4.8 (VB); also elsewhere on the board
VB_B: C22.1, D3.1 (K), U5.8 (VB); also elsewhere on the board
VB_C: C23.1, D4.1 (K), U6.8 (VB); also elsewhere on the board
VS_A: C21.2, NT7.2, U4.6 (VS); also elsewhere on the board
VS_B: C22.2, NT8.2, U5.6 (VS); also elsewhere on the board
VS_C: C23.2, NT9.2, U6.6 (VS); also elsewhere on the board

Notes on the sheet:
每相一片半桥驱动 IR2101S：上管靠自举（D、C 1 μF）供电；栅极电阻 10 Ω（例题 2）；死区由 MCU 定时器给。

Parts:
C27, C28, C29: 100n; C_0402_1005Metric
C30, C31, C32: 1n; C_0402_1005Metric
J2: MOTOR UVW; TerminalBlock_Phoenix_MKDS-1,5-3_1x03_P5.00mm_Horizontal
NT1, NT2, NT3, NT4, NT5, NT6: NetTie; NetTie-2_SMD_Pad0.5mm
R21, R22, R23: 2m 1%; R_2512_6332Metric
U7, U8, U9: INA240A1D; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C27.1, C28.1, C29.1, U7.6 (V+), U7.7 (REF1), U8.6 (V+), U8.7 (REF1), U9.6 (V+), U9.7 (REF1); also elsewhere on the board
GND: C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, U7.2 (GND), U7.3 (REF2), U7.4 (GND), U8.2 (GND), U8.3 (REF2), U8.4 (GND), U9.2 (GND), U9.3 (REF2), U9.4 (GND); also elsewhere on the board
ISNS_A: C30.1, U7.5; also elsewhere on the board
ISNS_B: C31.1, U8.5; also elsewhere on the board
ISNS_C: C32.1, U9.5; also elsewhere on the board
MOT_A: J2.1, NT2.1, R21.2
MOT_B: J2.2, NT4.1, R22.2
MOT_C: J2.3, NT6.1, R23.2
SNSN_A: NT2.2, U7.1 (-); also elsewhere on the board
SNSN_B: NT4.2, U8.1 (-); also elsewhere on the board
SNSN_C: NT6.2, U9.1 (-); also elsewhere on the board
SNSP_A: NT1.2, U7.8 (+); also elsewhere on the board
SNSP_B: NT3.2, U8.8 (+); also elsewhere on the board
SNSP_C: NT5.2, U9.8 (+); also elsewhere on the board
SW_A: NT1.1, R21.1; also elsewhere on the board
SW_B: NT3.1, R22.1; also elsewhere on the board
SW_C: NT5.1, R23.1; also elsewhere on the board

Notes on the sheet:
相线上串 2 mΩ 采样电阻（R21–R23），INA240A1 放大 20 倍：40 mV/A，零点 1.65 V，量程 ±41 A（例题 1）。J2 接电机三相。

Parts:
C40, C41, C42, C43, C46: 100n; C_0402_1005Metric
C44: 4.7u; C_0402_1005Metric
C45: 1u; C_0402_1005Metric
C47, C48: 10p; C_0402_1005Metric
R30: 10k; R_0402_1005Metric
TP1: SWDIO; TestPoint_Pad_D1.0mm
TP2: SWCLK; TestPoint_Pad_D1.0mm
TP3: NRST; TestPoint_Pad_D1.0mm
TP4: +3V3; TestPoint_Pad_D1.0mm
TP5: GND; TestPoint_Pad_D1.0mm
TP10: +12V; TestPoint_Pad_D1.0mm
TP11: +1V8; TestPoint_Pad_D1.0mm
TP12: BOOT0; TestPoint_Pad_D1.0mm
TP13: BRK_G; TestPoint_Pad_D1.0mm
TP14: BRK_GD; TestPoint_Pad_D1.0mm
TP15: BRK_ISEN; TestPoint_Pad_D1.0mm
TP16: BRK_PWM; TestPoint_Pad_D1.0mm
TP17: BRK_S; TestPoint_Pad_D1.0mm
TP18: CAN_RXD; TestPoint_Pad_D1.0mm
TP19: CAN_TXD; TestPoint_Pad_D1.0mm
TP21: ENC_A_F; TestPoint_Pad_D1.0mm
TP22: ENC_B_F; TestPoint_Pad_D1.0mm
TP23: ENC_CLK; TestPoint_Pad_D1.0mm
TP24: ENC_CS_N; TestPoint_Pad_D1.0mm
TP25: ENC_MISO; TestPoint_Pad_D1.0mm
TP26: ENC_MOSI; TestPoint_Pad_D1.0mm
TP27: ENC_RST_N; TestPoint_Pad_D1.0mm
TP28: ENC_SCK; TestPoint_Pad_D1.0mm
TP29: ENC_Z_F; TestPoint_Pad_D1.0mm
TP31: GH_A; TestPoint_Pad_D1.0mm
TP32: GH_B; TestPoint_Pad_D1.0mm
TP33: GH_C; TestPoint_Pad_D1.0mm
TP34: GL_A; TestPoint_Pad_D1.0mm
TP35: GL_B; TestPoint_Pad_D1.0mm
TP36: GL_C; TestPoint_Pad_D1.0mm
TP37: HO_A; TestPoint_Pad_D1.0mm
TP38: HO_B; TestPoint_Pad_D1.0mm
TP39: HO_C; TestPoint_Pad_D1.0mm
TP40: ISNS_A; TestPoint_Pad_D1.0mm
TP41: ISNS_B; TestPoint_Pad_D1.0mm
TP42: ISNS_C; TestPoint_Pad_D1.0mm
TP43: LO_A; TestPoint_Pad_D1.0mm
TP44: LO_B; TestPoint_Pad_D1.0mm
TP45: LO_C; TestPoint_Pad_D1.0mm
TP46: OSC_IN; TestPoint_Pad_D1.0mm
TP47: OSC_OUT; TestPoint_Pad_D1.0mm
TP48: PWM_AH; TestPoint_Pad_D1.0mm
TP49: PWM_AL; TestPoint_Pad_D1.0mm
TP50: PWM_BH; TestPoint_Pad_D1.0mm
TP51: PWM_BL; TestPoint_Pad_D1.0mm
TP52: PWM_CH; TestPoint_Pad_D1.0mm
TP53: PWM_CL; TestPoint_Pad_D1.0mm
TP54: SNSN_A; TestPoint_Pad_D1.0mm
TP55: SNSN_B; TestPoint_Pad_D1.0mm
TP56: SNSN_C; TestPoint_Pad_D1.0mm
TP57: SNSP_A; TestPoint_Pad_D1.0mm
TP58: SNSP_B; TestPoint_Pad_D1.0mm
TP59: SNSP_C; TestPoint_Pad_D1.0mm
TP60: SSI_CLK; TestPoint_Pad_D1.0mm
TP61: SSI_DATA; TestPoint_Pad_D1.0mm
TP64: VBUS_AUX; TestPoint_Pad_D1.0mm
TP66: VB_A; TestPoint_Pad_D1.0mm
TP67: VB_B; TestPoint_Pad_D1.0mm
TP68: VB_C; TestPoint_Pad_D1.0mm
TP70: VS_A; TestPoint_Pad_D1.0mm
TP71: VS_B; TestPoint_Pad_D1.0mm
TP72: VS_C; TestPoint_Pad_D1.0mm
U10: STM32G431CBT6; LQFP-48_7x7mm_P0.5mm
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+1V8: TP11.1; also elsewhere on the board
+3V3: C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, TP4.1, U10.1 (VBAT), U10.20 (VREF+), U10.21 (VDDA), U10.24 (VDD), U10.36 (VDD), U10.48 (VDD); also elsewhere on the board
+12V: TP10.1; also elsewhere on the board
BOOT0: R30.1, TP12.1, U10.45 (PB8)
BRK_G: TP13.1; also elsewhere on the board
BRK_GD: TP14.1; also elsewhere on the board
BRK_ISEN: TP15.1, U10.16 (PB0); also elsewhere on the board
BRK_PWM: TP16.1, U10.43 (PB6); also elsewhere on the board
BRK_S: TP17.1; also elsewhere on the board
CAN_RXD: TP18.1, U10.33 (PA11); also elsewhere on the board
CAN_TXD: TP19.1, U10.34 (PA12); also elsewhere on the board
ENC_A_F: TP21.1; also elsewhere on the board
ENC_B_F: TP22.1; also elsewhere on the board
ENC_CLK: TP23.1; also elsewhere on the board
ENC_CS_N: TP24.1, U10.12 (PA4); also elsewhere on the board
ENC_MISO: TP25.1, U10.14 (PA6); also elsewhere on the board
ENC_MOSI: TP26.1, U10.15 (PA7); also elsewhere on the board
ENC_RST_N: TP27.1, U10.17 (PB1); also elsewhere on the board
ENC_SCK: TP28.1, U10.13 (PA5); also elsewhere on the board
ENC_Z_F: TP29.1; also elsewhere on the board
GH_A: TP31.1; also elsewhere on the board
GH_B: TP32.1; also elsewhere on the board
GH_C: TP33.1; also elsewhere on the board
GL_A: TP34.1; also elsewhere on the board
GL_B: TP35.1; also elsewhere on the board
GL_C: TP36.1; also elsewhere on the board
GND: C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, R30.2, TP5.1, U10.19 (VSSA), U10.23 (VSS), U10.35 (VSS), U10.47 (VSS), Y1.2, Y1.4; also elsewhere on the board
HO_A: TP37.1; also elsewhere on the board
HO_B: TP38.1; also elsewhere on the board
HO_C: TP39.1; also elsewhere on the board
ISNS_A: TP40.1, U10.8 (PA0); also elsewhere on the board
ISNS_B: TP41.1, U10.9 (PA1); also elsewhere on the board
ISNS_C: TP42.1, U10.10 (PA2); also elsewhere on the board
LO_A: TP43.1; also elsewhere on the board
LO_B: TP44.1; also elsewhere on the board
LO_C: TP45.1; also elsewhere on the board
NRST: C46.1, TP3.1, U10.7 (PG10)
OSC_IN: C47.1, TP46.1, U10.5 (PF0), Y1.1
OSC_OUT: C48.1, TP47.1, U10.6 (PF1), Y1.3
PWM_AH: TP48.1, U10.30 (PA8); also elsewhere on the board
PWM_AL: TP49.1, U10.27 (PB13); also elsewhere on the board
PWM_BH: TP50.1, U10.31 (PA9); also elsewhere on the board
PWM_BL: TP51.1, U10.28 (PB14); also elsewhere on the board
PWM_CH: TP52.1, U10.32 (PA10); also elsewhere on the board
PWM_CL: TP53.1, U10.29 (PB15); also elsewhere on the board
SNSN_A: TP54.1; also elsewhere on the board
SNSN_B: TP55.1; also elsewhere on the board
SNSN_C: TP56.1; also elsewhere on the board
SNSP_A: TP57.1; also elsewhere on the board
SNSP_B: TP58.1; also elsewhere on the board
SNSP_C: TP59.1; also elsewhere on the board
SSI_CLK: TP60.1, U10.40 (PB3); also elsewhere on the board
SSI_DATA: TP61.1, U10.41 (PB4); also elsewhere on the board
SWCLK: TP2.1, U10.38 (PA14)
SWDIO: TP1.1, U10.37 (PA13)
VBUS_AUX: TP64.1; also elsewhere on the board
VBUS_SNS: U10.11 (PA3); also elsewhere on the board
VB_A: TP66.1; also elsewhere on the board
VB_B: TP67.1; also elsewhere on the board
VB_C: TP68.1; also elsewhere on the board
VS_A: TP70.1; also elsewhere on the board
VS_B: TP71.1; also elsewhere on the board
VS_C: TP72.1; also elsewhere on the board

Notes on the sheet:
STM32G431（示例选型）：TIM1 三相互补 PWM、ADC 采三相电流与母线电压、SPI1 读编码器接口芯片 U14（模式 0，≤ 5 MHz）、SPI3 读 SSI、TIM4_CH1（PB6）抱闸 PWM、ADC1_IN15（PB0）抱闸电流、FDCAN1；8 MHz 晶振；TP1–TP5 是烧录口和电源测试点。B 版：设计对照，不投产。

Schematic: io.kicad_sch, DRV-JOINT · 编码器接口与 CAN Encoder and CAN

Parts:
C50, C51, C52: 220p; C_0402_1005Metric
C53, C54, C55, C56, C57, C58, C61: 100n; C_0402_1005Metric
C59, C60: 1u; C_0402_1005Metric
J3: ENC ABZ; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J4: ENC SSI; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J5: CAN; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R31, R32, R33: 1k; R_0402_1005Metric
R34, R35: 120; R_0402_1005Metric
U11, U12: MAX3485; SOIC-8_3.9x4.9mm_P1.27mm
U13: MCP2562-E/SN; SOIC-8_3.9x4.9mm_P1.27mm
U14: WQ-ENCIF; QFN-16-1EP_3x3mm_P0.5mm_EP1.7x1.7mm
U15: AP2112K-1.8; SOT-23-5
Y2: 50MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm

Connections:
+1V8: C58.1, C60.1, U14.7 (VCCD), U15.5 (VOUT); also elsewhere on the board
+3V3: C53.1, C54.1, C56.1, C57.1, C59.1, C61.1, U11.2 (~RE), U11.3 (DE), U11.8 (VCC), U12.8 (VCC), U13.5 (Vio), U14.13 (VDDIO), U15.1 (VIN), U15.3 (EN), Y2.1 (EN), Y2.4 (Vdd); also elsewhere on the board
+5V: C55.1, J3.1, J4.1, J5.4, U13.3 (VDD); also elsewhere on the board
CANH: J5.1, R35.1, U13.7 (CANH)
CANL: J5.2, R35.2, U13.6 (CANL)
CAN_RXD: U13.4 (RXD); also elsewhere on the board
CAN_TXD: U13.1 (TXD); also elsewhere on the board
ENC_A: J3.3, R31.1
ENC_A_F: C50.1, R31.2, U14.1 (ENC_A); also elsewhere on the board
ENC_B: J3.4, R32.1
ENC_B_F: C51.1, R32.2, U14.2 (ENC_B); also elsewhere on the board
ENC_CLK: U14.5 (CLK), Y2.3 (OUT); also elsewhere on the board
ENC_CS_N: U14.9 (CS_N); also elsewhere on the board
ENC_MISO: U14.12 (MISO); also elsewhere on the board
ENC_MOSI: U14.11 (MOSI); also elsewhere on the board
ENC_RST_N: U14.6 (RST_N); also elsewhere on the board
ENC_SCK: U14.10 (SCLK); also elsewhere on the board
ENC_Z: J3.5, R33.1
ENC_Z_F: C52.1, R33.2, U14.3 (ENC_Z); also elsewhere on the board
GND: C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, J3.2, J4.2, J5.3, U11.5 (GND), U12.2 (~RE), U12.3 (DE), U12.4 (DI), U12.5 (GND), U13.2 (VSS), U13.8 (STBY), U14.4 (GND), U14.8 (GND), U14.14 (GND), U14.17 (EP), U15.2 (GND), Y2.2 (GND); also elsewhere on the board
SSIC_N: J4.4, U11.7 (B)
SSIC_P: J4.3, U11.6 (A)
SSID_N: J4.6, R34.2, U12.7 (B)
SSID_P: J4.5, R34.1, U12.6 (A)
SSI_CLK: U11.4 (DI); also elsewhere on the board
SSI_DATA: U12.1 (RO); also elsewhere on the board

Notes on the sheet:
J3 增量编码器 A/B/Z 经 1 kΩ / 220 pF 滤波（例题 4）进 MCU；J4 输出端绝对值编码器 SSI（两片 RS-485 收发）；J5 CAN（MCP2562，120 Ω 终端）。
