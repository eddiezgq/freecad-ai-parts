# Repository eddiezgq/freecad-ai-parts (continued)

## KiCad design factory/designs/ctrl-ls/kicad/ctrl-ls.kicad_pcb (continued)

Parts:
C501: 22n/50V; C_0603_1608Metric
C502, C504: 100n/50V; C_0603_1608Metric
C503: 2.2u; C_0805_2012Metric
C505: 10u/50V; C_1210_3225Metric
C506: 100n; C_0603_1608Metric
D501, D502, D503, D504: ES3D; D_SMC
D505, D506, D507, D508: SMBJ24A; D_SMB
J501: SOLENOIDS; JST_VH_B8P-VH_1x08_P3.96mm_Vertical
J502: STEPPER; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Q501, Q502, Q503, Q504: BSC040N08NS5; TDSON-8-1
Q505, Q506, Q507, Q508: 2N7002; SOT-23
R501, R502, R503, R504: 4.7k; R_0603_1608Metric
R505, R506, R507, R508, R512, R513: 10k; R_0603_1608Metric
R509, R510: 120m; R_2010_5025Metric
R511: 22k; R_0603_1608Metric
U501: TMC2226-SA; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.75x6.2mm_ThermalVias

Connections:
+3V3: C506.1, R505.1, R506.1, R507.1, R508.1, R513.1, U501.19 (VCC_IO); also elsewhere on the board
+15V: R501.1, R502.1, R503.1, R504.1; also elsewhere on the board
+24V: C502.2, C504.1, C505.1, D505.2 (A), D506.2 (A), D507.2 (A), D508.2 (A), J501.1, J501.3, J501.5, J501.7, U501.3 (VS), U501.26 (VS); also elsewhere on the board
GND: C503.2, C504.2, C505.2, C506.2, Q501.1 (S), Q501.2 (S), Q501.3 (S), Q502.1 (S), Q502.2 (S), Q502.3 (S), Q503.1 (S), Q503.2 (S), Q503.3 (S), Q504.1 (S), Q504.2 (S), Q504.3 (S), Q505.2 (S), Q506.2 (S), Q507.2 (S), Q508.2 (S), R509.2, R510.2, R512.2, U501.6 (GND), U501.10 (SPREAD), U501.12 (MS1_AD0), U501.14 (MS2_AD1), U501.17 (CLK), U501.18 (PDN_UART), U501.22 (GND), U501.24 (STDBY), U501.29 (GND); also elsewhere on the board
SOL1_D: D501.2 (A), J501.2, Q501.5 (D)
SOL1_G: Q501.4 (G), Q505.3 (D), R501.2; also elsewhere on the board
SOL1_K: D501.1 (K), D505.1 (K); also elsewhere on the board
SOL2_D: D502.2 (A), J501.4, Q502.5 (D)
SOL2_G: Q502.4 (G), Q506.3 (D), R502.2; also elsewhere on the board
SOL2_K: D502.1 (K), D506.1 (K); also elsewhere on the board
SOL3_D: D503.2 (A), J501.6, Q503.5 (D)
SOL3_G: Q503.4 (G), Q507.3 (D), R503.2
SOL3_K: D503.1 (K), D507.1 (K); also elsewhere on the board
SOL4_D: D504.2 (A), J501.8, Q504.5 (D)
SOL4_G: Q504.4 (G), Q508.3 (D), R504.2; also elsewhere on the board
SOL4_K: D504.1 (K), D508.1 (K); also elsewhere on the board
SOL_FOOT: Q508.1 (G), R508.2; also elsewhere on the board
SOL_REV: Q507.1 (G), R507.2; also elsewhere on the board
SOL_TRIM: Q505.1 (G), R505.2; also elsewhere on the board
SOL_WIPE: Q506.1 (G), R506.2; also elsewhere on the board
STP_5V: C503.1, R511.1, U501.11 (5VOUT)
STP_BRA: R509.1, U501.27 (BRA)
STP_BRB: R510.1, U501.2 (BRB)
STP_CPI: C501.2, U501.8 (CPI)
STP_CPO: C501.1, U501.7 (CPO)
STP_DIAG: U501.15 (DIAG); also elsewhere on the board
STP_DIR: U501.23 (DIR); also elsewhere on the board
STP_EN: R513.2, U501.5 (~EN); also elsewhere on the board
STP_OA1: J502.1, U501.28 (OA1)
STP_OA2: J502.2, U501.25 (OA2)
STP_OB1: J502.3, U501.1 (OB1)
STP_OB2: J502.4, U501.4 (OB2)
STP_STEP: U501.20 (STEP); also elsewhere on the board
STP_VCP: C502.1, U501.9 (VCP)
STP_VREF: R511.2, R512.1, U501.21 (VREF)

Notes on the sheet:
电磁铁 4 路（剪线、拨线、倒缝、抬压脚）：80 V 管低边开关，关断经 ES3D + SMBJ24A 钳位；栅极由 2N7002 反相从 15 V 驱动，主控复位时不吸合。针距步进 TMC2226 独立模式（STEP/DIR），采样 0.12 Ω。

Parts:
C40, C41, C42, C43, C46: 100n; C_0402_1005Metric
C44: 4.7u; C_0402_1005Metric
C45: 1u; C_0402_1005Metric
C47, C48: 15p; C_0402_1005Metric
C701, C702: 100n; C_0603_1608Metric
C703, C704, C705, C706, C707, C708: 220p; C_0603_1608Metric
J701: ENCODER; JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J702: PEDAL; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R30: 10k; R_0402_1005Metric
R701, R801: 10k; R_0603_1608Metric
R702, R802: 20k; R_0603_1608Metric
R703, R704, R705, R706, R707, R708: 2.2k; R_0603_1608Metric
R709, R710, R711, R712, R713, R714: 1k; R_0603_1608Metric
TP1, TP30: SWDIO; TestPoint_Pad_D1.0mm
TP2, TP29: SWCLK; TestPoint_Pad_D1.0mm
TP3: NRST; TestPoint_Pad_D1.0mm
TP4: +3V3; TestPoint_Pad_D1.0mm
TP5: GND; TestPoint_Pad_D1.0mm
TP6: +3V3_ISO; TestPoint_Pad_D1.0mm
TP7: BRO_B; TestPoint_Pad_D1.0mm
TP8: CLAMP; TestPoint_Pad_D1.0mm
TP9: CLAMP_M; TestPoint_Pad_D1.0mm
TP10: ENC_Z_F; TestPoint_Pad_D1.0mm
TP11: FB_RC; TestPoint_Pad_D1.0mm
TP12: FB_REF; TestPoint_Pad_D1.0mm
TP13: FREQ; TestPoint_Pad_D1.0mm
TP14: GATE_IC; TestPoint_Pad_D1.0mm
TP15: HALL_V_F; TestPoint_Pad_D1.0mm
TP16: HALL_W_F; TestPoint_Pad_D1.0mm
TP17: ICOMP; TestPoint_Pad_D1.0mm
TP18: OVP_1; TestPoint_Pad_D1.0mm
TP19: OVP_2; TestPoint_Pad_D1.0mm
TP20: RLY_G; TestPoint_Pad_D1.0mm
TP21: RO_ISO; TestPoint_Pad_D1.0mm
TP22: SOL1_G; TestPoint_Pad_D1.0mm
TP23: SOL1_K; TestPoint_Pad_D1.0mm
TP24: SOL2_G; TestPoint_Pad_D1.0mm
TP25: SOL2_K; TestPoint_Pad_D1.0mm
TP26: SOL3_K; TestPoint_Pad_D1.0mm
TP27: SOL4_G; TestPoint_Pad_D1.0mm
TP28: SOL4_K; TestPoint_Pad_D1.0mm
TP31: TOP_V; TestPoint_Pad_D1.0mm
TP32: TXN_ISO; TestPoint_Pad_D1.0mm
TP33: VBUS_SNS_1; TestPoint_Pad_D1.0mm
TP34: VBUS_SNS_2; TestPoint_Pad_D1.0mm
TP35: VSENSE_1; TestPoint_Pad_D1.0mm
TP36: VSENSE_2; TestPoint_Pad_D1.0mm
U10: STM32G431CBT6; LQFP-48_7x7mm_P0.5mm
U701: SN74LVC14APWR; TSSOP-14_4.4x5mm_P0.65mm
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C701.1, TP4.1, U10.1 (VBAT), U10.20 (VREF+), U10.21 (VDDA), U10.24 (VDD), U10.36 (VDD), U10.48 (VDD), U701.14 (VCC); also elsewhere on the board
+3V3_ISO: TP6.1; also elsewhere on the board
+5V: J701.1, J702.1, R703.1, R704.1, R705.1, R706.1, R707.1, R708.1; also elsewhere on the board
BOOT0: R30.1, U10.45 (PB8)
BRO_B: TP7.1; also elsewhere on the board
CLAMP: TP8.1; also elsewhere on the board
CLAMP_M: TP9.1; also elsewhere on the board
ENC_A: J701.3, R703.2, R709.1
ENC_A_F: U10.43 (PB6), U701.2
ENC_A_RC: C703.1, R709.2, U701.1
ENC_B: J701.4, R704.2, R710.1
ENC_B_F: U10.44 (PB7), U701.4
ENC_B_RC: C704.1, R710.2, U701.3
ENC_Z: J701.5, R705.2, R711.1
ENC_Z_F: TP10.1, U10.14 (PA6), U701.6
ENC_Z_RC: C705.1, R711.2, U701.5
FB_RC: TP11.1; also elsewhere on the board
FB_REF: TP12.1; also elsewhere on the board
FREQ: TP13.1; also elsewhere on the board
GATE_IC: TP14.1; also elsewhere on the board
GND: C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C701.2, C702.2, C703.2, C704.2, C705.2, C706.2, C707.2, C708.2, J701.2, J702.3, R30.2, R702.2, R802.2, TP5.1, U10.19 (VSSA), U10.23 (VSS), U10.35 (VSS), U10.47 (VSS), U701.7 (GND), Y1.2, Y1.4; also elsewhere on the board
HALL_U: J701.6, R706.2, R712.1
HALL_U_F: U10.2 (PC13), U701.8
HALL_U_RC: C706.1, R712.2, U701.9
HALL_V: J701.7, R707.2, R713.1
HALL_V_F: TP15.1, U10.3 (PC14), U701.10
HALL_V_RC: C707.1, R713.2, U701.11
HALL_W: J701.8, R708.2, R714.1
HALL_W_F: TP16.1, U10.4 (PC15), U701.12
HALL_W_RC: C708.1, R714.2, U701.13
ICOMP: TP17.1; also elsewhere on the board
IPM_SD: U10.26 (PB12); also elsewhere on the board
IPM_T: U10.12 (PA4); also elsewhere on the board
ISNS_U: U10.9 (PA1); also elsewhere on the board
ISNS_V: U10.15 (PA7); also elsewhere on the board
ISNS_W: U10.16 (PB0); also elsewhere on the board
NRST: C46.1, TP3.1, U10.7 (PG10)
OSC_IN: C47.1, U10.5 (PF0), Y1.1
OSC_OUT: C48.1, U10.6 (PF1), Y1.3
OVP_1: TP18.1; also elsewhere on the board
OVP_2: TP19.1; also elsewhere on the board
PEDAL: C702.1, R701.2, R702.1, U10.17 (PB1)
PEDAL_IN: J702.2, R701.1
PFC_OFF: U10.46 (PB9); also elsewhere on the board
PNL_RX: U10.11 (PA3); also elsewhere on the board
PNL_TX: U10.10 (PA2); also elsewhere on the board
PWM_UH: U10.30 (PA8); also elsewhere on the board
PWM_UL: U10.27 (PB13); also elsewhere on the board
PWM_VH: U10.31 (PA9); also elsewhere on the board
PWM_VL: U10.28 (PB14); also elsewhere on the board
PWM_WH: U10.32 (PA10); also elsewhere on the board
PWM_WL: U10.29 (PB15); also elsewhere on the board
RLY_G: TP20.1; also elsewhere on the board
RO_ISO: TP21.1; also elsewhere on the board
SOL1_G: TP22.1; also elsewhere on the board
SOL1_K: TP23.1; also elsewhere on the board
SOL2_G: TP24.1; also elsewhere on the board
SOL2_K: TP25.1; also elsewhere on the board
SOL3_K: TP26.1; also elsewhere on the board
SOL4_G: TP27.1; also elsewhere on the board
SOL4_K: TP28.1; also elsewhere on the board
SOL_FOOT: U10.39 (PA15); also elsewhere on the board
SOL_REV: U10.34 (PA12); also elsewhere on the board
SOL_TRIM: U10.13 (PA5); also elsewhere on the board
SOL_WIPE: U10.33 (PA11); also elsewhere on the board
STP_DIAG: U10.18 (PB2); also elsewhere on the board
STP_DIR: U10.42 (PB5); also elsewhere on the board
STP_EN: U10.25 (PB11); also elsewhere on the board
STP_STEP: U10.41 (PB4); also elsewhere on the board
SWCLK: TP2.1, TP29.1, U10.38 (PA14)
SWDIO: TP1.1, TP30.1, U10.37 (PA13)
TOP_V: TP31.1; also elsewhere on the board
TXN_ISO: TP32.1; also elsewhere on the board
VBUS_SNS: U10.8 (PA0); also elsewhere on the board
VBUS_SNS_1: TP33.1; also elsewhere on the board
VBUS_SNS_2: TP34.1; also elsewhere on the board
VB_OK: R801.1; also elsewhere on the board
VB_OK_SNS: R801.2, R802.1, U10.40 (PB3)
VSENSE_1: TP35.1; also elsewhere on the board
VSENSE_2: TP36.1; also elsewhere on the board

Notes on the sheet:
STM32G431（沿用关节驱动板的最小系统）。编码器 A/B/Z 与霍尔 U/V/W 上拉 5 V、RC 滤波后经 SN74LVC14A 整形；脚踏板霍尔分压进 ADC；VB_OK 分压给主控看。TP1–TP5 是顶面烧录点；TP6–TP36 是底面 ICT 测试点（159e，针床从底面扎）。

Parts:
C601, C602, C606: 100n; C_0603_1608Metric
C603: 4.7u/25V; C_1206_3216Metric
C604, C605: 10u/25V; C_1206_3216Metric
J601: PANEL; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R601: 10k; R_0603_1608Metric
R602, R603: 680; R_0603_1608Metric
R604: 120; R_0603_1608Metric
U601: ADUM1201ARZ-RL7; SOIC-8_3.9x4.9mm_P1.27mm
U602: B0505S-1WR2; Converter_SIP4_B0505S
U603: AMS1117-3.3; SOT-223-3_TabPin2
U604: MAX3485ESA+T; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C601.1, U601.1 (VDD1); also elsewhere on the board
+3V3_ISO: C602.1, C605.1, C606.1, R601.1, R602.1, U601.8 (VDD2), U603.2 (VO), U604.8 (VCC); also elsewhere on the board
+5V: C603.1, U602.2 (Vin); also elsewhere on the board
+5V_ISO: C604.1, J601.1, U602.4 (+Vo), U603.3 (VI)
GND: C601.2, C603.2, U601.4 (GND1), U602.1 (GND); also elsewhere on the board
GND_ISO: C602.2, C604.2, C605.2, C606.2, J601.4, R603.2, U601.5 (GND2), U602.3 (0V), U603.1 (GND), U604.4 (DI), U604.5 (GND)
PNL_A: J601.2, R602.2, R604.1, U604.6 (A)
PNL_B: J601.3, R603.1, R604.2, U604.7 (B)
PNL_RX: U601.2 (VOA); also elsewhere on the board
PNL_TX: U601.3 (VIB); also elsewhere on the board
RO_ISO: R601.2, U601.7 (VIA), U604.1 (RO); also elsewhere on the board
TXN_ISO: U601.6 (VOB), U604.2 (~RE), U604.3 (DE); also elsewhere on the board

Notes on the sheet:
面板口：USART2 发送反相 → ADuM1201 → 隔离侧 MAX3485（3.3 V，由 B0505S 隔离 5 V 再经 AMS1117 降压）；发送信号同时控制 DE、/RE，DI 接地。J601 是人能碰到的唯一接口。

Schematic: thermal.kicad_sch, CTRL-LS · 散热 Heatsink

Notes on the sheet:
散热器（型号 159d2 定）：整流桥、升压管、升压二极管、功率模块共用一块，热阻 ≤ 1.05 K/W（计算书）。本页没有电气器件。
