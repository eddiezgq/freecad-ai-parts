# Repository eddiezgq/freecad-ai-parts (continued)

## KiCad design factory/designs/ctrl-ls/kicad/ctrl-ls.kicad_pcb (continued)

Board: 4 copper layers, 250.0 x 150.0 mm, 257 parts (31 on the bottom side), 150 nets.

Other parts of the board:
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad

Their connections:
PE: H1.1; also elsewhere on the board

File factory/designs/ctrl-ls/out/bom.csv (part):

物料编号,数值,封装,数量,位号,型号,厂家,立创编号,说明
BRG-GBU1006,GBU1006,Diode_Bridge_Vishay_GBU,1,BR101,GBU1006,LGE,C5183365,整流桥（符号和封装用 KiCad 官方库的 GBU 系列：1 +、2 ~、3 ~、4 −；装在散热器上）
CAP-0402,100n,C_0402_1005Metric,5,C40 C41 C42 C43 C46,,,,
CAP-0402,10p,C_0402_1005Metric,2,C47 C48,,,,
CAP-0402,1u,C_0402_1005Metric,1,C45,,,,VDDA
CAP-0402,4.7u,C_0402_1005Metric,1,C44,,,,
CAP-0603,100n,C_0603_1608Metric,11,C202 C207 C302 C308 C405 C506 C601 C602 C606 C701 C702,,,,
CAP-0603,100n/50V,C_0603_1608Metric,2,C502 C504,,,,
CAP-0603,10n,C_0603_1608Metric,2,C408 C418,,,,
CAP-0603,1n,C_0603_1608Metric,11,C205 C407 C409 C410 C411 C412 C413 C414 C415 C416 C417,,,,规格书 p.7 物料表 CISENSE 1 nF
CAP-0603,220p,C_0603_1608Metric,6,C703 C704 C705 C706 C707 C708,,,,
CAP-0603,22n/50V,C_0603_1608Metric,1,C501,,,,电荷泵（BOB 物料清单）
CAP-0603,4.7n,C_0603_1608Metric,1,C206,,,,电流环补偿（规格书 p.7 物料表 CICOMP 4.7 nF）
CAP-0805,1u/25V,C_0805_2012Metric,1,C201,,,,VCC 去耦（规格书没给值，设计取值）
CAP-0805,2.2u,C_0805_2012Metric,1,C503,,,,片内 5 V 稳压输出
CAP-0805,3.3u/25V,C_0805_2012Metric,1,C208,,,,规格书 p.7 CBRO 3 µF，取 3.3 µF
CAP-1206,10u/25V,C_1206_3216Metric,5,C309 C310 C404 C604 C605,,,,
CAP-1206,1u/50V,C_1206_3216Metric,1,C305,,,,
CAP-1206,4.7u/25V,C_1206_3216Metric,4,C401 C402 C403 C603,,,,自举电容：静态电流 300 µA（规格书）× 每个 PWM 周期 62.5 µs ≪ 4.7 µF × 1 V
CAP-1210,10u/50V,C_1210_3225Metric,1,C505,,,,VS 去耦
CAP-1812-1KV,15n/1kV,C_1812_4532Metric,1,C303,,,,RCD 钳位电容（计算书：≥ 11.6n）
CAP-1812-630V,100n/630V,C_1812_4532Metric,1,C406,,,,母线高频旁路，紧靠 P、N 引脚（规格书 4.1 节）
CAP-BULK-330U-500V,330u/500V,CP_Radial_D30.0mm_P10.00mm_SnapIn,3,C221 C222 C223,500MXH330MEFCSN30X50,Rubycon,C472902,500MXH330MEFCSN30X50（母线电容，计算书：3 只并联）
CAP-EL-1000U-10V,1000u/10V,CP_Radial_D8.0mm_P3.50mm,1,C307,,,,5 V 输出
CAP-EL-220U-25V,220u/25V,CP_Radial_D8.0mm_P3.50mm,1,C306,,,,15 V 输出（功率模块、校正控制器、继电器）
CAP-EL-470U-35V,470u/35V,CP_Radial_D10.0mm_P5.00mm,1,C304,,,,24 V 输出（电磁铁吸合的脉冲电流从这里出）
CAP-EL-47U-16V,47u/16V,CP_Elec_6.3x5.4,1,C301,,,,C 脚旁路 47 µF（规格书 p.8：起动 / 重启时间按 47 µF 给出）
CAP-FILM-1U-450V,1u/450V,C_Rect_L18.0mm_W8.0mm_P15.00mm_FKS3_FKP3,1,C104,,,,整流后高频旁路（吸收升压管开关电流，薄膜电容）
CAP-X2-470N,470n X2,C_Rect_L26.5mm_W10.5mm_P22.50mm_MKS4,1,C101,BFC233920474,Vishay,C511073,BFC233920474（封装待核对）
CAP-Y-2N2,2n2 Y1,C_Disc_D8.0mm_W5.0mm_P7.50mm,2,C102 C103,DE1E3RA222MA4BP01F,Murata,C907949,Y 电容（封装待核对）
CMC-8118RC,7.3mH 9.3A,L_CommonMode_Toroid_Vertical_L41.9mm_W20.3mm_Px15.24mm_Py22.86mm_Bourns_8100,1,L101,8118-RC,Bourns,,8118-RC（Bourns 8100 系列，KiCad 官方库同系列封装；159d2 由 FC-HLF2018 换来：那颗规格书读不出、库里没有封装）
CONN-AC,AC IN L/N,"TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizontal",1,J101,,,,交流输入：1 相线、2 零线。保护地线不上板：直接接电控箱的接地螺柱；板上的 Y 电容经安装孔 H1 接箱体（159d2b）
CONN-MOT,MOTOR U/V/W,"TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizontal",1,J401,,,,电机三相
CONN-VH8,SOLENOIDS,JST_VH_B8P-VH_1x08_P3.96mm_Vertical,1,J501,,,,电磁铁 4 路（每路 +24 V 与漏极）：剪线、拨线、倒缝、抬压脚
CONN-XH3,PEDAL,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,1,J702,,,,脚踏板（霍尔，0.5–4.5 V）
CONN-XH4,PANEL,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,J601,,,,操作面板（隔离侧，人能碰到的唯一接口）
CONN-XH4,STEPPER,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,J502,,,,针距步进电机
CONN-XH8,ENCODER,JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical,1,J701,,,,电机编码器与霍尔
DCDC-B0505S,B0505S-1WR2,Converter_SIP4_B0505S,1,U602,B0505S-1WR2,YLPTEC,C2992393,隔离电源 5 V → 5 V 1 W，隔离 1500 V 直流 1 分钟（Mornsun 原版规格书）。规格书写“行业标准引脚”、图读不出：按 1 W 单列直插行业通用排法 1 −Vin、2 +Vin、3 −Vo、4 +Vo、间距 2.54 mm 做封装，待核对
DIO-1N4007,1N4007,D_SMA,2,D203 D204,,,,欠压取样（规格书 p.7 DBRO1、DBRO2；贴片 M7 等效）
DIO-1N4148W,1N4148W,D_SOD-123,1,D101,,,,继电器线圈续流
DIO-1N5408,1N5408,D_DO-201AD_P15.24mm_Horizontal,1,D202,,,,旁路二极管：上电时浪涌电流绕过电感直接给母线电容充电（规格书 p.7 物料表 DBYP 的作用，型号是设计取值）
DIO-C3D06060A,C3D06060A,TO-220-2_Vertical,1,D201,C3D06060A,Wolfspeed (Cree),C5693025,升压二极管（碳化硅；符号和封装用 KiCad 官方库的 C3D06060A：1 阴极、2 阳极；装在散热器上）
DIO-ES3D,ES3D,D_SMC,7,D302 D303 D304 D501 D502 D503 D504,ES3D,onsemi,C241735,24 V 整流
DIO-US1M,US1M,D_SMA,1,D301,,,,钳位二极管（快恢复 1000 V）
FUSE-T10A,10A T,Fuseholder_Clip-5x20mm_Bel_FC-203-22_Lateral_P17.80x5.00mm_D1.17mm_Horizontal,1,F101,0215010.MXP,Littelfuse,C142733,0215010.MXP（5×20 mm 慢断，夹座安装；夹座封装待核对）
IC-74LVC14,SN74LVC14APWR,TSSOP-14_4.4x5mm_P0.65mm,1,U701,SN74LVC14APWR,Texas Instruments,C7663,施密特整形（六路）
IC-ADUM1201,ADUM1201ARZ-RL7,SOIC-8_3.9x4.9mm_P1.27mm,1,U601,ADUM1201ARZ-RL7,Analog Devices,C9669,数字隔离：B 通道主控 → 面板（发送），A 通道面板 → 主控（接收）
IC-LDO-3V3,AMS1117-3.3,SOT-223-3_TabPin2,2,U304 U603,,,,3.3 V（沿用关节驱动板）
IC-MCU-MC,STM32G431CBT6,LQFP-48_7x7mm_P0.5mm,1,U10,STM32G431CBT6,STMicroelectronics,C529355,主控（沿用关节驱动板）：TIM1 三相互补 PWM、片内运放采三相电流、ADC 测母线与模块温度、TIM4 编码器、USART2 面板口、TIM3 步进脉冲
IC-PFC-ICE3PCS01G,ICE3PCS01G,SOIC-14_3.9x8.7mm_P1.27mm,1,U201,ICE3PCS01G,Infineon,C192050,连续导通功率因数校正控制器
IC-RS485,MAX3485ESA+T,SOIC-8_3.9x4.9mm_P1.27mm,1,U604,MAX3485ESA+T,Analog Devices (Maxim),C18148,RS-485 收发（DE、/RE 由发送信号控制，DI 接地）
IC-TL431,TL431AIDBZR,SOT-23,1,U302,TL431AIDBZR,Texas Instruments,C23892,反馈基准
IC-TMC2226,TMC2226-SA,HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP2.75x6.2mm_ThermalVias,1,U501,TMC2226-SA,ADI / Trinamic,C6718351,针距步进驱动：MS1、MS2 接地（8 细分）、SPREAD 接地（静音模式）、CLK 接地（片内时钟）、PDN_UART 接地（停转时电流减半）、STDBY 接地；以上独立模式接法待核对规格书
IC-TOP266KG,TOP266KG,PowerIntegrations_eSOP-12B,1,U301,TOP266KG,Power Integrations,C568204,反激控制器（集成 725 V 开关管）；X 接 S、F 接 C
IND-PFC-CUSTOM,451uH,L_ETD59_Horizontal,1,L201,,,,升压电感（定制：ETD59 + 骨架 B66398，匝数、气隙、线径见计算书“按理论”）
IPM-STGIPS14K60T,STGIPS14K60T,ST_SDIP-25L,1,U401,STGIPS14K60T,STMicroelectronics,C5268145,三相智能功率模块（装在散热器上）。OUT_x 是上桥浮地参考，自举电容接在 VB_x 与 OUT_x 之间
MOS-2N7002,2N7002,SOT-23,6,Q101 Q202 Q505 Q506 Q507 Q508,,,,母线充好（校正控制器 VB_OK = 5 V）后吸合
MOS-80V,BSC040N08NS5,TDSON-8-1,4,Q501 Q502 Q503 Q504,BSC040N08NS5,Infineon,C534333,剪线电磁铁
MOS-IPW60R060P7,IPW60R060P7,TO-247-3_Vertical,1,Q201,IPW60R060P7,Infineon,C454258,升压开关管（TO-247：1 G、2 D、3 S；装在散热器上）
MOV-275,S14K275,RV_Disc_D15.5mm_W4.9mm_P7.5mm,1,RV101,B72214S0271K101,TDK,C7502584,B72214S0271K101（封装按 14 mm 盘片选，待核对）
NTC-2R5,2.5R,RV_Disc_D15.5mm_W4.9mm_P7.5mm,1,TH101,B57364S0259M000,TDK,C17362791,B57364S0259M000（上电浪涌限流，母线充好后由 K101 短接；封装按盘片选，待核对）
OPTO-PC817,PC817X2NSZ9F,SMDIP-4_W9.53mm,1,U303,PC817X2NSZ9F,Sharp,C390734,反馈光耦（这里不为隔离，只为把误差电流送进 C 脚）
RES-0402,10k,R_0402_1005Metric,1,R30,,,,BOOT0 下拉
RES-0603,100,R_0603_1608Metric,6,R403 R404 R405 R406 R407 R408,,,,输入 RC 滤波 100 Ω / 1 nF（0.1 µs ≪ 死区 1 µs，设计取值）
RES-0603,100k,R_0603_1608Metric,2,R104 R210,,,,
RES-0603,10k,R_0603_1608Metric,13,R202 R306 R307 R401 R505 R506 R507 R508 R512 R513 R601 R701 R801,,,,栅源下拉（设计取值）
RES-0603,120,R_0603_1608Metric,1,R604,,,,终端电阻（控制器在总线一端）
RES-0603,130k,R_0603_1608Metric,1,R213,,,,规格书 p.7 RBRO3 130 kΩ
RES-0603,15k,R_0603_1608Metric,3,R417 R418 R419,,,,
RES-0603,1k,R_0603_1608Metric,13,R103 R308 R309 R402 R414 R415 R416 R709 R710 R711 R712 R713 R714,,,,VB_OK 最多出 1 mA（ICE3PCS01G 规格书 p.19），只推管子栅极
RES-0603,2.2k,R_0603_1608Metric,6,R703 R704 R705 R706 R707 R708,,,,上拉到 5 V
RES-0603,200k,R_0603_1608Metric,3,R206 R207 R209,,,,BOFO 拉到 0.5 V 以上 = 不用升压跟随（规格书 p.13）；200 k / 200 k 照 p.7 物料表
RES-0603,20k,R_0603_1608Metric,4,R217 R221 R702 R802,,,,VSENSE 下臂
RES-0603,22k,R_0603_1608Metric,2,R423 R511,,,,
RES-0603,3.3,R_0603_1608Metric,1,R201,,,,栅极电阻 3.3 Ω（规格书 p.7 物料表 RGATE）
RES-0603,330k,R_0603_1608Metric,1,R208,,,,VB_OK 断开门限 = 5 V × 200/530 = 1.89 V（母线约 294 V）；330 k / 200 k 照 p.7 物料表 RVB1、RVB2，接法是按框图读的，待核对
RES-0603,4.7k,R_0603_1608Metric,4,R501 R502 R503 R504,,,,栅极上拉到 15 V
RES-0603,47k,R_0603_1608Metric,1,R305,,,,
RES-0603,51,R_0603_1608Metric,1,R204,,,,ISENSE 串联电阻约 50 Ω，限浪涌（规格书 p.4、p.7 物料表 RCS）
RES-0603,66.5k,R_0603_1608Metric,1,R205,,,,开关频率：规格书 67 kΩ → 65 kHz（p.7–8），取 E96 最近的 66.5 kΩ
RES-0603,680,R_0603_1608Metric,2,R602 R603,,,,总线空闲偏置（A 上拉、B 下拉）
RES-0603,82k,R_0603_1608Metric,1,R304,,,,加权取样：24 V 与 15 V 各占一半（设计取值），下臂 10 k
RES-1206,1.02M,R_1206_3216Metric,3,R214 R215 R216,,,,VSENSE 上臂 3 × 1.02M（理想 3.1 MΩ）：母线 = 2.5 V × (1 + 上/下)
RES-1206,1.13M,R_1206_3216Metric,3,R218 R219 R220,,,,OVP 上臂 3 × 1.13M：第二级过压约 110 % 额定（429 V，设计取值）
RES-1206,1M,R_1206_3216Metric,5,R101 R102 R420 R421 R422,,,,X 电容放电：2 MΩ × 0.47 µF = 0.94 s（拔插头后 1 s 内放到安全）
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
## KiCad design factory/designs/drv-joint/kicad/drv-joint.kicad_pcb

Notes on the sheet:
关节伺服驱动板 DRV-JOINT：48 V、三相、相电流采样 + 编码器接口 + CAN。示例设计，未经硬件验证。

Parts:
C1: 470u/63V; CP_Elec_16x17.5
C2: 10n; C_0402_1005Metric
J1: 48V IN; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
NT10: NetTie; NetTie-2_SMD_Pad0.5mm
R1, R2: 51k; R_0402_1005Metric
R3: 6.8k; R_0402_1005Metric
TP14: EN12; TestPoint_Pad_D1.0mm
TP18: FB12; TestPoint_Pad_D1.0mm
TP50: SW12; TestPoint_Pad_D1.0mm
TP51: SW_CB; TestPoint_Pad_D1.0mm
TP53: VBUS_SNS; TestPoint_Pad_D1.0mm
TP57: VB_MID; TestPoint_Pad_D1.0mm

Connections:
EN12: TP14.1; also elsewhere on the board
FB12: TP18.1; also elsewhere on the board
GND: C1.2, C2.2, J1.2, R3.2; also elsewhere on the board
SW12: TP50.1; also elsewhere on the board
SW_CB: TP51.1; also elsewhere on the board
VBUS: C1.1, J1.1, NT10.1; also elsewhere on the board
VBUS_AUX: NT10.2, R1.1; also elsewhere on the board
VBUS_SNS: C2.1, R2.2, R3.1, TP53.1; also elsewhere on the board
VB_MID: R1.2, R2.1, TP57.1

Notes on the sheet:
48 V 从 J1 进；母线电容 C1 470 μF / 63 V（例题 3）；R1、R2、R3 分压给 MCU 测母线电压（48 V → 3.0 V）。示例设计，未经硬件验证。

Parts:
C3: 2.2u/100V; C_1206_3216Metric
C4: 100n; C_0402_1005Metric
C5: 22u/25V; C_1206_3216Metric
C6, C7: 10u/25V; C_1206_3216Metric
D1: 60V 1A; D_SMA
L1: 22u; L_Bourns_SRN6045TA
R4: 100k; R_0402_1005Metric
R5: 147k; R_0402_1005Metric
R6: 10k; R_0402_1005Metric
U1: LMR16006YQ; SOT-23-6
U2: AMS1117-5.0; SOT-223-3_TabPin2
U3: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C7.1, U3.2 (VO); also elsewhere on the board
+5V: C6.1, U2.2 (VO), U3.3 (VI); also elsewhere on the board
+12V: C5.1, L1.2, R5.1, U2.3 (VI); also elsewhere on the board
EN12: R4.2, U1.4 (~SHDN); also elsewhere on the board
FB12: R5.2, R6.1, U1.3 (FB); also elsewhere on the board
GND: C3.2, C5.2, C6.2, C7.2, D1.2 (A), R6.2, U1.2 (GND), U2.1 (GND), U3.1 (GND); also elsewhere on the board
SW12: C4.2, D1.1 (K), L1.1, U1.6 (SW); also elsewhere on the board
SW_CB: C4.1, U1.1 (CB); also elsewhere on the board
VBUS_AUX: C3.1, R4.1, U1.5 (VIN); also elsewhere on the board

Notes on the sheet:
U1 LMR16006Y 把 48 V 降到 12 V（栅极驱动用），U2、U3 线性稳压出 5 V（编码器、CAN）和 3.3 V（MCU、采样放大）。L1 22 μH、反馈 147 k / 10 k 的算法见设计说明。

Parts:
C11, C12, C13: 2.2u/100V; C_1206_3216Metric
Q1, Q2, Q3, Q4, Q5, Q6: BSC040N08NS5; TDSON-8-1

Connections:
GH_A: Q1.4 (G); also elsewhere on the board
GH_B: Q3.4 (G); also elsewhere on the board
GH_C: Q5.4 (G); also elsewhere on the board
GL_A: Q2.4 (G); also elsewhere on the board
GL_B: Q4.4 (G); also elsewhere on the board
GL_C: Q6.4 (G); also elsewhere on the board
GND: C11.2, C12.2, C13.2, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S); also elsewhere on the board
SW_A: Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D); also elsewhere on the board
SW_B: Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D); also elsewhere on the board
SW_C: Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.5 (D); also elsewhere on the board
VBUS: C11.1, C12.1, C13.1, Q1.5 (D), Q3.5 (D), Q5.5 (D); also elsewhere on the board

Notes on the sheet:
三个半桥，每相上下两个 MOSFET（示例选型 BSC040N08NS5，80 V）；C11–C13 每相就近吸收开关电流。

Parts:
C21, C22, C23, C24, C25, C26: 1u/25V; C_0402_1005Metric
D2, D3, D4: 100V 1A; D_SOD-123
NT7, NT8, NT9: NetTie; NetTie-2_SMD_Pad0.5mm
R10, R11, R12, R13, R14, R15: 10; R_0402_1005Metric
U4, U5, U6: IR2101S; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+12V: C24.1, C25.1, C26.1, D2.2 (A), D3.2 (A), D4.2 (A), U4.1 (VCC), U5.1 (VCC), U6.1 (VCC); also elsewhere on the board
GH_A: R10.2; also elsewhere on the board
GH_B: R12.2; also elsewhere on the board
GH_C: R14.2; also elsewhere on the board
GL_A: R11.2; also elsewhere on the board
GL_B: R13.2; also elsewhere on the board
GL_C: R15.2; also elsewhere on the board
GND: C24.2, C25.2, C26.2, U4.4 (COM), U5.4 (COM), U6.4 (COM); also elsewhere on the board
HO_A: R10.1, U4.7 (HO); also elsewhere on the board
HO_B: R12.1, U5.7 (HO); also elsewhere on the board
HO_C: R14.1, U6.7 (HO); also elsewhere on the board
LO_A: R11.1, U4.5 (LO); also elsewhere on the board
LO_B: R13.1, U5.5 (LO); also elsewhere on the board
LO_C: R15.1, U6.5 (LO); also elsewhere on the board
PWM_AH: U4.2 (HIN); also elsewhere on the board
PWM_AL: U4.3 (LIN); also elsewhere on the board
PWM_BH: U5.2 (HIN); also elsewhere on the board
PWM_BL: U5.3 (LIN); also elsewhere on the board
PWM_CH: U6.2 (HIN); also elsewhere on the board
PWM_CL: U6.3 (LIN); also elsewhere on the board
SW_A: NT7.1; also elsewhere on the board
SW_B: NT8.1; also elsewhere on the board
SW_C: NT9.1; also elsewhere on the board
VB_A: C21.1, D2.1 (K), U4.8 (VB); also elsewhere on the board
VB_B: C22.1, D3.1 (K), U5.8 (VB); also elsewhere on the board
VB_C: C23.1, D4.1 (K), U6.8 (VB); also elsewhere on the board
VS_A: C21.2, NT7.2, U4.6 (VS); also elsewhere on the board
VS_B: C22.2, NT8.2, U5.6 (VS); also elsewhere on the board
VS_C: C23.2, NT9.2, U6.6 (VS); also elsewhere on the board

Notes on the sheet:
每相一片半桥驱动 IR2101S：上管靠自举（D、C 1 μF）供电；栅极电阻 10 Ω（例题 2）；死区由 MCU 定时器给。

Parts:
C27, C28, C29: 100n; C_0402_1005Metric
C30, C31, C32: 1n; C_0402_1005Metric
J2: MOTOR UVW; TerminalBlock_Phoenix_MKDS-1,5-3_1x03_P5.00mm_Horizontal
NT1, NT2, NT3, NT4, NT5, NT6: NetTie; NetTie-2_SMD_Pad0.5mm
R21, R22, R23: 2m 1%; R_2512_6332Metric
U7, U8, U9: INA240A1D; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C27.1, C28.1, C29.1, U7.6 (V+), U7.7 (REF1), U8.6 (V+), U8.7 (REF1), U9.6 (V+), U9.7 (REF1); also elsewhere on the board
GND: C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, U7.2 (GND), U7.3 (REF2), U7.4 (GND), U8.2 (GND), U8.3 (REF2), U8.4 (GND), U9.2 (GND), U9.3 (REF2), U9.4 (GND); also elsewhere on the board
ISNS_A: C30.1, U7.5; also elsewhere on the board
ISNS_B: C31.1, U8.5; also elsewhere on the board
ISNS_C: C32.1, U9.5; also elsewhere on the board
MOT_A: J2.1, NT2.1, R21.2
MOT_B: J2.2, NT4.1, R22.2
MOT_C: J2.3, NT6.1, R23.2
SNSN_A: NT2.2, U7.1 (-); also elsewhere on the board
SNSN_B: NT4.2, U8.1 (-); also elsewhere on the board
SNSN_C: NT6.2, U9.1 (-); also elsewhere on the board
SNSP_A: NT1.2, U7.8 (+); also elsewhere on the board
SNSP_B: NT3.2, U8.8 (+); also elsewhere on the board
SNSP_C: NT5.2, U9.8 (+); also elsewhere on the board
SW_A: NT1.1, R21.1; also elsewhere on the board
SW_B: NT3.1, R22.1; also elsewhere on the board
SW_C: NT5.1, R23.1; also elsewhere on the board

Notes on the sheet:
相线上串 2 mΩ 采样电阻（R21–R23），INA240A1 放大 20 倍：40 mV/A，零点 1.65 V，量程 ±41 A（例题 1）。J2 接电机三相。
