# Repository eddiezgq/freecad-ai-parts

File README.md:

# FreeCAD AI Parts

AI 原生的 FreeCAD 与零件产品库。把厂商零件抽象成"端口 + 参数 + 包络"的黑箱，由 AI 根据需求选型、做确定性校验，再在 FreeCAD 里按端口装配成系统。

第一步围绕机器人：V1 目标是在 FreeCAD 里用一句自然语言需求，完成机器人关节模组（伺服电机 → 减速器 → 输出，配驱动器与轴承）的选型、校验、布局和 BOM 输出。

## 架构

| 层 | 目录 | 作用 |
| --- | --- | --- |
| L5 应用与视图 | `freecad_addon/` | FreeCAD 工作台：AI 对话、零件面板、包络装配、干涉检查 |
| L4 服务接口 | `mcp_server/` | MCP 工具 + REST，供 agent 和其他客户端调用 |
| L3 配置引擎 | `engine/` | 需求解析、候选求解、性能链计算、规则校验、方案解释 |
| L2 组件知识库 | `kb/` | 组件、参数、端口类型、连接规则、向量索引 |
| L1 数据采集 | `ingest/` | 来源登记、规格书解析、归一化、人工复核 |
| 契约 | `schema/` | 各层共用的 JSON Schema 与端口类型库 |

设计原则：LLM 负责理解需求、提议候选和解释结果；凡影响"能不能用"的判断，都由确定性程序校验兜底。完整说明见 [docs/](docs/README.md)。

## 当前状态

V1 各阶段的**开发部分已全部完成**（2026-10-01，比计划大幅提前），剩下的是需要人完成的验收、规则表核对与厂商数据授权，见 [开发计划的进度一节](docs/plan.md#进度截至-2026-10-01)。

| 阶段 | 内容 | 开发 |
| --- | --- | --- |
| M0 | 环境与骨架 | 完成 |
| M1 | schema 与端口类型库，golden 用例 | 完成（有条件通过验收） |
| M2 | 数据流水线：合成规格书、LLM 抽取与核对、人工复核队列、准确率评测 | 完成 |
| M3 | 配置引擎：11 项校验、候选求解与排序、中英文解释 | 完成 |
| M4a | MCP 工具与 REST，外部客户端接入 | 完成 |
| M4b | FreeCAD：按端口布局、干涉检查、截图、URDF、工作台与对话面板 | 完成 |
| M5 | 一句话需求解析、端到端演示、样例输出 | 完成 |

组件数据目前全部是虚构的测试组件（ADR-0015）。真实厂商数据须先取得书面授权。

## 快速开始

需要 Python 3.11+。

```bash
pip install -e ".[dev]"
python -m mcp_server.e2e "六轴机械臂第 2 关节：输出连续扭矩 25 N·m、峰值 50 N·m，输出转速 30 rpm，220 V 单相供电，EtherCAT 总线" --out out/
```

`out/` 中有方案汇总、BOM、系统 JSON 和 URDF；样例见 [`examples/joint2/`](examples/joint2/)。加上 FreeCAD 做干涉检查与截图、在 FreeCAD 里用自然语言对话的步骤，见 [演示](docs/demo.md)。

| 入口 | 说明 |
| --- | --- |
| 命令行端到端演示 | `python -m mcp_server.e2e`，见 [docs/demo.md](docs/demo.md) |
| 外部 MCP 客户端（Claude Desktop 等） | 14 个工具与提示模板，见 [docs/mcp-client.md](docs/mcp-client.md) |
| REST | `freecad-ai-parts-mcp --http`，路由见 `mcp_server/rest.py` |
| FreeCAD 工作台与对话面板 | `python -m freecad_addon.install`，见 [freecad_addon/README.md](freecad_addon/README.md) |

### 测试

```bash
python -m ruff check .
python -m pytest -v
```

- 数据库测试需要 PostgreSQL 16 与 pgvector：设置 `FAP_TEST_DATABASE_URL` 后运行，未设置时跳过
- FreeCAD 测试（标记 `freecad`）的运行方式见 [freecad_addon/README.md](freecad_addon/README.md)
- CI 中这两类测试都必须运行

## 开发约定

完整规则见 [docs/implementation-rules.md](docs/implementation-rules.md)；AI 编码助手遵守 [CLAUDE.md](CLAUDE.md)。

- 所有改动从分支走 PR，CI 全绿后合并
- schema 先行、测试先行：先定契约和验收用例，再实现
- 范围、接口或 schema 的任何变更，先改文档和决策记录（`docs/adr/`），再改代码
- 原始规格书不入库，只在 `data/sources.yaml` 登记来源与许可

## 许可证

[Apache License 2.0](LICENSE)。本仓库为开放核心的开源部分；厂商数据的使用遵守各来源的条款，见 [ADR-0001](docs/adr/0001-open-core-and-license.md) 与 [ADR-0005](docs/adr/0005-data-sources.md)。

## KiCad design factory/designs/ctrl-ls/kicad/ctrl-ls.kicad_pcb

File factory/README.md:

> **来源**：本目录搬自问渠仓库（wenquest）的 `factory/`，提交 `8710ae0c`（2026-10-06），原样搬入，之后在本仓库维护（ADR-0058）。
> 搬入时的改动只有：数字工厂测试里与问渠零件库互核的几份文件放在 `library_ref/`，测试路径随之改。
> 演示工厂“问渠减速器厂”与 WQR-105 的数据是虚构的演示数据。

# 问渠虚拟工厂（ERPNext 版）

一座只生产一种产品的虚拟工厂：**二级圆柱齿轮减速器 WQR-105**（传动比 10.5）。装好后，ERPNext 里已经有完整的产品结构、工艺路线、工作中心、质量检验方案、供应商和客户，学生可以直接从销售订单做到发货，走通 MRP、采购、车间报工、质检、序列号追溯和成本核算。

| 文件 | 内容 |
| --- | --- |
| `docker-compose.yml` | ERPNext v16.34.1 单机版（基于官方 frappe_docker），浏览器端口 8090 |
| `seed.py` | 一键导入工厂主数据（可重复运行） |
| `factory/data.py` | 工厂的全部数据：物料、BOM、工艺、工位、检验标准。改工厂就改这个文件 |
| `工厂设计.md` | 工厂设计说明：传动设计、产品结构、成本、瓶颈分析（由 data.py 自动生成） |
| `实验指导.md` | 6 个教学实验：从接单到发货，含不合格品处理和瓶颈改进 |
| `tests/` | 数据一致性检查，以及对照 ERPNext v16 字段定义的模拟导入 |

## 电脑要求

Windows 10/11，内存 16 GB 更流畅（最低 8 GB），磁盘空余 15 GB。ERPNext 会同时运行十来个容器，第一次下载镜像约 2 GB。

## 一、安装 Docker Desktop

从 [docker.com](https://www.docker.com/products/docker-desktop/) 下载 Docker Desktop for Windows，按默认选项安装（使用 WSL 2），装完重启电脑，打开 Docker Desktop 等它显示 “Engine running”。

## 二、启动 ERPNext

本文件夹在问渠仓库的 `factory` 目录里。把仓库克隆到比如 `D:\code\wenquest`（`git clone git@github.com:<你的用户名>/wenquest.git`），在 PowerShell 里：

```powershell
cd D:\code\wenquest\factory
docker compose up -d
docker compose logs -f create-site
```

最后一条命令会显示建站过程，看到它结束（出现 `Current Site set to frontend` 一类的字样后自动退出），按 `Ctrl+C` 离开。首次约 5–10 分钟。

浏览器打开下面这个地址，用户名 `Administrator`，密码 `admin`：

```
http://localhost:8090
```

## 三、完成初始设置向导

第一次登录会进入设置向导，按下面填：

| 项目 | 填写 |
| --- | --- |
| 语言 | English 或 简体中文（两种都可以，导入脚本不受影响） |
| 国家 / 时区 / 币种 | United States / America/New_York / USD |
| 公司名称 | 问渠减速器厂 WenQuest Gearbox（缩写 `WQ`） |
| 会计科目表 | 默认的 Standard |
| 示例数据 | 不要生成（如果向导问到） |

## 四、导入工厂数据

```powershell
py -m pip install -r requirements.txt
py seed.py --opening-stock
```

大约一两分钟。屏幕上会逐项显示进度，最后一行是“完成：新建 N 条”。`--opening-stock` 会放入小五金和齿轮油的期初库存，让实验聚焦在轴承、钢材、铸锻件这些关键物料上。脚本可以重复运行，已存在的记录会跳过。

导入后检查：在 ERPNext 里打开 **BOM** 列表，应有 13 个已提交的 BOM；打开 `WQR-105` 的 BOM，总成本应与《工厂设计.md》末尾的标准成本（约 1,232 美元）接近。

## 五、日常操作

| 要做的事 | 命令 |
| --- | --- |
| 暂停（保留数据） | `docker compose stop` |
| 继续 | `docker compose start` |
| 清空重来（删除全部数据） | `docker compose down -v`，然后重复第二到第四步 |
| 修改工厂设计 | 改 `factory/data.py` → `py -m factory.make_docs` 更新设计文档 → `py seed.py` 导入新增内容 |
| 运行检查 | `py -m pip install pytest`，然后 `py -m pytest tests` |

## 说明

- 默认账号密码都是 `admin`，只适合在自己电脑上学习。要放到服务器给学生用，需要改密码、加 HTTPS，再告诉 Claude 把它并入学习平台的部署。
- `seed.py` 发出的每一条数据都已对照 ERPNext v16 的字段定义做过模拟检查（`tests/test_factory.py`），但还没有在真实的 ERPNext 上运行过。第一次导入如果报错，把屏幕上“出错：”后面的内容发给 Claude。
- 所有供应商、客户都是虚构的示例单位；单价是教学用的示意数值。
- `tests/schemas/` 里的 JSON 文件取自 ERPNext（GPL v3），只用于测试。

Notes on the sheet:
平缝机控制器 CTRL-LS：单相 90–250 V 输入 → 功率因数校正 → 390 V 母线 → 智能功率模块 → 主轴电机；电磁铁 4 路、针距步进、隔离面板口。整块板以母线负端为地，只有面板口隔离。示例设计，未经硬件验证。

Parts:
BR101: GBU1006; Diode_Bridge_Vishay_GBU
C101: 470n X2; C_Rect_L26.5mm_W10.5mm_P22.50mm_MKS4
C102, C103: 2n2 Y1; C_Disc_D8.0mm_W5.0mm_P7.50mm
C104: 1u/450V; C_Rect_L18.0mm_W8.0mm_P15.00mm_FKS3_FKP3
D101: 1N4148W; D_SOD-123
F101: 10A T; Fuseholder_Clip-5x20mm_Bel_FC-203-22_Lateral_P17.80x5.00mm_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
J101: AC IN L/N; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
K101: G5LE-1 DC12; Relay_SPDT_Omron-G5LE-1
L101: 7.3mH 9.3A; L_CommonMode_Toroid_Vertical_L41.9mm_W20.3mm_Px15.24mm_Py22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
Q101: 2N7002; SOT-23
R101, R102: 1M; R_1206_3216Metric
R103: 1k; R_0603_1608Metric
R104: 100k; R_0603_1608Metric
RV101: S14K275; RV_Disc_D15.5mm_W4.9mm_P7.5mm
TH101: 2.5R; RV_Disc_D15.5mm_W4.9mm_P7.5mm

Connections:
+15V: D101.1 (K), K101.2; also elsewhere on the board
GND: Q101.2 (S), R104.2; also elsewhere on the board
L_C: C102.1, K101.1, L101.2, TH101.1
L_F: C101.1, F101.2, L101.1, R101.1, RV101.1
L_IN: F101.1, J101.1
L_R: BR101.2, K101.3, TH101.2; also elsewhere on the board
N_C: BR101.3, C103.1, L101.4; also elsewhere on the board
N_IN: C101.2, J101.2, L101.3, R102.2, RV101.2
PE: C102.2, C103.2; also elsewhere on the board
RECT_N: BR101.4 (-), C104.2; also elsewhere on the board
RLY_G: Q101.1 (G), R103.2, R104.1; also elsewhere on the board
RLY_K: D101.2 (A), K101.5, Q101.3 (D)
VB_OK: R103.1; also elsewhere on the board
VRECT: BR101.1 (+), C104.1; also elsewhere on the board
XDIS: R101.2, R102.1

Notes on the sheet:
交流 L/N 从 J101 进（保护地线直接接电控箱的接地螺柱，Y 电容经安装孔 H1 接箱体）：保险丝 F101、压敏 RV101、X 电容 C101（R101/R102 放电）、共模电感 L101、Y 电容 C102/C103；热敏电阻 TH101 限上电浪涌，母线充好后校正控制器的 VB_OK 让 K101 吸合短接它；整流桥 BR101。

Parts:
C201: 1u/25V; C_0805_2012Metric
C202, C207: 100n; C_0603_1608Metric
C205: 1n; C_0603_1608Metric
C206: 4.7n; C_0603_1608Metric
C208: 3.3u/25V; C_0805_2012Metric
C221, C222, C223: 330u/500V; CP_Radial_D30.0mm_P10.00mm_SnapIn
D201: C3D06060A; TO-220-2_Vertical
D202: 1N5408; D_DO-201AD_P15.24mm_Horizontal
D203, D204: 1N4007; D_SMA
L201: 451uH; L_ETD59_Horizontal
Q201: IPW60R060P7; TO-247-3_Vertical
Q202: 2N7002; SOT-23
R201: 3.3; R_0603_1608Metric
R202: 10k; R_0603_1608Metric
R203: 10m; R_2512_6332Metric
R204: 51; R_0603_1608Metric
R205: 66.5k; R_0603_1608Metric
R206, R207, R209: 200k; R_0603_1608Metric
R208: 330k; R_0603_1608Metric
R210: 100k; R_0603_1608Metric
R211, R212: 3.9M; R_1206_3216Metric
R213: 130k; R_0603_1608Metric
R214, R215, R216: 1.02M; R_1206_3216Metric
R217, R221: 20k; R_0603_1608Metric
R218, R219, R220: 1.13M; R_1206_3216Metric
U201: ICE3PCS01G; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+15V: C201.1, C202.1, U201.12 (VCC); also elsewhere on the board
BOFO: R206.2, R207.1, U201.1 (BOFO)
BOP: C208.1, R212.2, R213.1, U201.9 (BOP)
BRO_A: D203.1 (K), D204.1 (K), R211.1
BRO_B: R211.2, R212.1; also elsewhere on the board
FREQ: R205.1, U201.5 (FREQ); also elsewhere on the board
GATE_IC: R201.1, U201.13 (GATE); also elsewhere on the board
GATE_PFC: Q201.1 (G), R201.2, R202.1
GND: C201.2, C202.2, C205.2, C206.2, C207.2, C208.2, C221.2, C222.2, C223.2, Q201.3 (S), Q202.2 (S), R202.2, R203.2, R205.2, R207.2, R209.2, R210.2, R213.2, R217.2, R221.2, U201.3 (SGND), U201.14 (PGND); also elsewhere on the board
ICOMP: C206.1, U201.4 (ICOMP); also elsewhere on the board
ISENSE: C205.1, R204.2, U201.2 (ISENSE)
L_R: D203.2 (A); also elsewhere on the board
N_C: D204.2 (A); also elsewhere on the board
OVP: R220.2, R221.1, U201.10 (OVP)
OVP_1: R218.2, R219.1; also elsewhere on the board
OVP_2: R219.2, R220.1; also elsewhere on the board
PFC_OFF: Q202.1 (G), R210.1; also elsewhere on the board
RECT_N: R203.1, R204.1; also elsewhere on the board
SW_PFC: D201.2 (A), L201.2, Q201.2 (D)
VBTHL_EN: Q202.3 (D), R208.2, R209.1, U201.7 (VBTHL_EN)
VBUS: C221.1, C222.1, C223.1, D201.1 (K), D202.1 (K), R214.1, R218.1; also elsewhere on the board
VB_OK: U201.6 (VB_OK); also elsewhere on the board
VRECT: D202.2 (A), L201.1; also elsewhere on the board
VREF: C207.1, R206.1, R208.1, U201.8 (VREF)
VSENSE: R216.2, R217.1, U201.11 (VSENSE)
VSENSE_1: R214.2, R215.1; also elsewhere on the board
VSENSE_2: R215.2, R216.1; also elsewhere on the board

Notes on the sheet:
ICE3PCS01G 连续导通升压校正：L201 定制电感、Q201 600 V 60 mΩ、D201 碳化硅二极管、C221–C223 母线 3 × 330 µF / 500 V；R203 10 mΩ 采样（ISENSE 取负压）；外围阻容照规格书 V3.0 p.7 物料表，母线分压按 390 V 重算。主控拉 PFC_OFF 可关断校正。

Parts:
C301: 47u/16V; CP_Elec_6.3x5.4
C302, C308: 100n; C_0603_1608Metric
C303: 15n/1kV; C_1812_4532Metric
C304: 470u/35V; CP_Radial_D10.0mm_P5.00mm
C305: 1u/50V; C_1206_3216Metric
C306: 220u/25V; CP_Radial_D8.0mm_P3.50mm
C307: 1000u/10V; CP_Radial_D8.0mm_P3.50mm
C309, C310: 10u/25V; C_1206_3216Metric
D301: US1M; D_SMA
D302, D303, D304: ES3D; D_SMC
R301, R302: 2M; R_1206_3216Metric
R303, R310: 6.2k; R_2512_6332Metric
R304: 82k; R_0603_1608Metric
R305: 47k; R_0603_1608Metric
R306, R307: 10k; R_0603_1608Metric
R308, R309: 1k; R_0603_1608Metric
T301: FLY-24/15/5; Transformer_EPCOS_B66359A1013T_Horizontal
U301: TOP266KG; PowerIntegrations_eSOP-12B
U302: TL431AIDBZR; SOT-23
U303: PC817X2NSZ9F; SMDIP-4_W9.53mm
U304: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C310.1, U304.2 (VO); also elsewhere on the board
+5V: C307.1, C309.1, D304.1 (K), U304.3 (VI); also elsewhere on the board
+15V: C306.1, D303.1 (K), R305.1, U303.4; also elsewhere on the board
+24V: C304.1, C305.1, D302.1 (K), R304.1, R308.1; also elsewhere on the board
CLAMP: C303.2, D301.1 (K), R310.2; also elsewhere on the board
CLAMP_M: R303.2, R310.1; also elsewhere on the board
FB_K: R307.1, R309.2, U302.1 (K), U303.2
FB_LED: R308.2, R309.1, U303.1
FB_RC: C308.1, R307.2; also elsewhere on the board
FB_REF: C308.2, R304.2, R305.2, R306.1, U302.2 (REF); also elsewhere on the board
FLY_5: D304.2 (A), T301.12 (S3+)
FLY_15: D303.2 (A), T301.10 (S2+)
FLY_24: D302.2 (A), T301.8 (S1+)
FLY_D: D301.2 (A), T301.3 (P-), U301.6 (D)
GND: C301.2, C302.2, C304.2, C305.2, C306.2, C307.2, C309.2, C310.2, R306.2, T301.9 (S1-), T301.11 (S2-), T301.13 (S3-), U301.2 (X), U301.7 (S), U301.8 (S), U301.9 (S), U301.10 (S), U301.11 (S), U301.12 (S), U302.3 (A), U304.1 (GND); also elsewhere on the board
TOP_C: C301.1, C302.1, U301.3 (C), U301.4 (F), U303.3
TOP_V: R302.2, U301.1 (V); also elsewhere on the board
TOP_V1: R301.2, R302.1
VBUS: C303.1, R301.1, R303.1, T301.1 (P+); also elsewhere on the board

Notes on the sheet:
TOP266KG 反激：母线 → 24 V（电磁铁、步进）、15 V（功率模块、校正、继电器）、5 V；AMS1117 再出 3.3 V。整块板共地，三路输出不隔离；TL431 + 光耦按 24 V / 15 V 加权稳压。钳位 R303/C303 要变压器漏感才能算，按样机调。

Parts:
C401, C402, C403: 4.7u/25V; C_1206_3216Metric
C404: 10u/25V; C_1206_3216Metric
C405: 100n; C_0603_1608Metric
C406: 100n/630V; C_1812_4532Metric
C407, C409, C410, C411, C412, C413, C414, C415, C416, C417: 1n; C_0603_1608Metric
C408, C418: 10n; C_0603_1608Metric
J401: MOTOR U/V/W; TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizont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
R401: 10k; R_0603_1608Metric
R402, R414, R415, R416: 1k; R_0603_1608Metric
R403, R404, R405, R406, R407, R408: 100; R_0603_1608Metric
R411, R412, R413: 25m; R_2512_6332Metric
R417, R418, R419: 15k; R_0603_1608Metric
R420, R421, R422: 1M; R_1206_3216Metric
R423: 22k; R_0603_1608Metric
U401: STGIPS14K60T; ST_SDIP-25L

Connections:
+3V3: R401.1, R402.1, R417.1, R418.1, R419.1; also elsewhere on the board
+15V: C404.1, C405.1, U401.5 (VCC); also elsewhere on the board
GND: C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, C416.2, C417.2, C418.2, R411.2, R412.2, R413.2, R423.2, U401.8 (GND); also elsewhere on the board
IN_UH: C409.1, R403.2, U401.4 (HINU)
IN_UL: C410.1, R404.2, U401.3 (~LINU)
IN_VH: C411.1, R405.2, U401.10 (HINV)
IN_VL: C412.1, R406.2, U401.9 (~LINV)
IN_WH: C413.1, R407.2, U401.14 (HINW)
IN_WL: C414.1, R408.2, U401.13 (~LINW)
IPM_SD: C407.1, R401.2, U401.15 (~SD); also elsewhere on the board
IPM_T: C408.1, R402.2, U401.16 (T1); also elsewhere on the board
ISNS_U: C415.1, R414.2, R417.2; also elsewhere on the board
ISNS_V: C416.1, R415.2, R418.2; also elsewhere on the board
ISNS_W: C417.1, R416.2, R419.2; also elsewhere on the board
MOT_U: J401.1, U401.24 (U)
MOT_V: J401.2, U401.21 (V)
MOT_W: J401.3, U401.18 (W)
N_U: R411.1, R414.1, U401.23 (NU)
N_V: R412.1, R415.1, U401.20 (NV)
N_W: R413.1, R416.1, U401.17 (NW)
OUT_U: C401.2, U401.1 (OUTU)
OUT_V: C402.2, U401.6 (OUTV)
OUT_W: C403.2, U401.11 (OUTW)
PWM_UH: R403.1; also elsewhere on the board
PWM_UL: R404.1; also elsewhere on the board
PWM_VH: R405.1; also elsewhere on the board
PWM_VL: R406.1; also elsewhere on the board
PWM_WH: R407.1; also elsewhere on the board
PWM_WL: R408.1; also elsewhere on the board
VBUS: C406.1, R420.1, U401.19, U401.22, U401.25; also elsewhere on the board
VBUS_SNS: C418.1, R422.2, R423.1; also elsewhere on the board
VBUS_SNS_1: R420.2, R421.1; also elsewhere on the board
VBUS_SNS_2: R421.2, R422.1; also elsewhere on the board
VB_U: C401.1, U401.2 (VBOOTU)
VB_V: C402.1, U401.7 (VBOOTV)
VB_W: C403.1, U401.12 (VBOOTW)

Notes on the sheet:
STGIPS14K60T 三相智能功率模块：PWM 经 100 Ω / 1 nF 进模块，SD 上拉 3.3 V，模块内热敏电阻经 1 kΩ 上拉进 ADC；三相下桥 25 mΩ 采样经偏置网络（1 k / 15 k）进主控片内运放（放大 8 倍，零点 1.65 V）；母线电压 3 MΩ / 22 kΩ 分压。
